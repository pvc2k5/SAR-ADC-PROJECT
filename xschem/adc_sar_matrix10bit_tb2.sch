v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 10030 -3390 10030 -3350 {}
L 4 10010 -3390 10050 -3390 {}
L 4 9950 -3390 9950 -3350 {}
L 4 9930 -3390 9970 -3390 {}
L 4 9870 -3390 9870 -3350 {}
L 4 9850 -3390 9890 -3390 {}
L 4 9790 -3390 9790 -3350 {}
L 4 9770 -3390 9810 -3390 {}
L 4 9710 -3390 9710 -3350 {}
L 4 9690 -3390 9730 -3390 {}
L 4 10170 -3390 10170 -3350 {}
L 4 10150 -3390 10190 -3390 {}
L 4 9670 -3350 10230 -3350 {}
L 4 10065 -3395 10075 -3395 {}
L 4 10085 -3395 10095 -3395 {}
L 4 10105 -3395 10115 -3395 {}
L 4 10125 -3395 10135 -3395 {}
L 4 9690 -3400 9730 -3400 {}
L 4 9770 -3400 9810 -3400 {}
L 4 9850 -3400 9890 -3400 {}
L 4 9930 -3400 9970 -3400 {}
L 4 10010 -3400 10050 -3400 {}
L 4 10150 -3400 10190 -3400 {}
L 4 10030 -3440 10030 -3400 {}
L 4 9950 -3440 9950 -3400 {}
L 4 9870 -3440 9870 -3400 {}
L 4 9790 -3440 9790 -3400 {}
L 4 9710 -3440 9710 -3400 {}
L 4 10170 -3440 10170 -3400 {}
L 4 10030 -3260 10030 -3220 {}
L 4 10010 -3260 10050 -3260 {}
L 4 9950 -3260 9950 -3220 {}
L 4 9930 -3260 9970 -3260 {}
L 4 9870 -3260 9870 -3220 {}
L 4 9850 -3260 9890 -3260 {}
L 4 9790 -3260 9790 -3220 {}
L 4 9770 -3260 9810 -3260 {}
L 4 9710 -3260 9710 -3220 {}
L 4 9690 -3260 9730 -3260 {}
L 4 10170 -3260 10170 -3220 {}
L 4 10150 -3260 10190 -3260 {}
L 4 9670 -3310 10230 -3310 {}
L 4 10065 -3265 10075 -3265 {}
L 4 10085 -3265 10095 -3265 {}
L 4 10105 -3265 10115 -3265 {}
L 4 10125 -3265 10135 -3265 {}
L 4 9690 -3270 9730 -3270 {}
L 4 9770 -3270 9810 -3270 {}
L 4 9850 -3270 9890 -3270 {}
L 4 9930 -3270 9970 -3270 {}
L 4 10010 -3270 10050 -3270 {}
L 4 10150 -3270 10190 -3270 {}
L 4 10030 -3310 10030 -3270 {}
L 4 9950 -3310 9950 -3270 {}
L 4 9870 -3310 9870 -3270 {}
L 4 9790 -3310 9790 -3270 {}
L 4 9710 -3310 9710 -3270 {}
L 4 10170 -3310 10170 -3270 {}
L 4 9630 -3310 9670 -3310 {}
L 4 9630 -3350 9670 -3350 {}
L 4 9600 -3350 9630 -3360 {}
L 4 9600 -3310 9630 -3300 {}
L 4 9570 -3310 9600 -3310 {}
L 4 9570 -3350 9600 -3350 {}
L 4 9530 -3350 9570 -3350 {}
L 4 9530 -3310 9570 -3310 {}
L 4 10270 -3370 10270 -3290 {}
L 4 10270 -3290 10350 -3330 {}
L 4 10270 -3370 10350 -3330 {}
L 4 10230 -3350 10270 -3350 {}
L 4 10230 -3310 10270 -3310 {}
L 4 9700 -3450 9710 -3440 {}
L 4 9710 -3490 9710 -3460 {}
L 4 9780 -3450 9790 -3440 {}
L 4 9780 -3470 9780 -3460 {}
L 4 9790 -3490 9790 -3460 {}
L 4 9800 -3510 9800 -3460 {}
L 4 9860 -3450 9870 -3440 {}
L 4 9860 -3470 9860 -3460 {}
L 4 9870 -3490 9870 -3460 {}
L 4 9880 -3510 9880 -3460 {}
L 4 9940 -3450 9950 -3440 {}
L 4 9940 -3470 9940 -3460 {}
L 4 9950 -3490 9950 -3460 {}
L 4 9960 -3510 9960 -3460 {}
L 4 10020 -3450 10030 -3440 {}
L 4 10020 -3470 10020 -3460 {}
L 4 10030 -3490 10030 -3460 {}
L 4 10040 -3510 10040 -3460 {}
L 4 10160 -3450 10170 -3440 {}
L 4 10160 -3470 10160 -3460 {}
L 4 10170 -3490 10170 -3460 {}
L 4 10180 -3510 10180 -3460 {}
L 4 9670 -3470 10160 -3470 {}
L 4 9670 -3490 10170 -3490 {}
L 4 9670 -3510 10180 -3510 {}
L 4 9700 -3210 9710 -3220 {}
L 4 9710 -3200 9710 -3170 {}
L 4 9780 -3210 9790 -3220 {}
L 4 9780 -3200 9780 -3190 {}
L 4 9790 -3200 9790 -3170 {}
L 4 9800 -3200 9800 -3150 {}
L 4 9860 -3210 9870 -3220 {}
L 4 9860 -3200 9860 -3190 {}
L 4 9870 -3200 9870 -3170 {}
L 4 9880 -3200 9880 -3150 {}
L 4 9940 -3210 9950 -3220 {}
L 4 9940 -3200 9940 -3190 {}
L 4 9950 -3200 9950 -3170 {}
L 4 9960 -3200 9960 -3150 {}
L 4 10020 -3210 10030 -3220 {}
L 4 10020 -3200 10020 -3190 {}
L 4 10030 -3200 10030 -3170 {}
L 4 10040 -3200 10040 -3150 {}
L 4 10160 -3210 10170 -3220 {}
L 4 10160 -3200 10160 -3190 {}
L 4 10170 -3200 10170 -3170 {}
L 4 10180 -3200 10180 -3150 {}
L 4 9670 -3190 10160 -3190 {}
L 4 9670 -3170 10170 -3170 {}
L 4 9670 -3150 10180 -3150 {}
L 4 10350 -3330 10420 -3330 {}
L 4 9700 -3510 9700 -3460 {}
L 4 9700 -3200 9700 -3190 {}
T {Tie C0 to VDD - Enable C0 at P-input
Tie C0 to VSS - Disable C0 at N-input} 2460 -2740 0 0 0.3 0.3 {}
T {127 Wafflecaps (13x10-1) for 7 Bit. 
3 Bin-Caps (4/8F, 2/8F and 1/8F) for 3 extra Bit.
+1 Unitcap.
--> 1023 unitcaps + 1 unitcap = 1024 unitcaps for 10 Bit
1024*0.45fF=0.4608pF} 8490 -3370 0 0 0.6 0.6 {}
T {INP} 9460 -3380 0 0 0.6 0.6 {}
T {INN} 9460 -3330 0 0 0.6 0.6 {}
T {+} 10270 -3370 0 0 0.6 0.6 {}
T {-} 10270 -3330 0 0 0.6 0.6 {}
T {C0} 9710 -3390 0 0 0.6 0.6 {}
T {C} 9790 -3390 0 0 0.6 0.6 {}
T {2C} 9870 -3390 0 0 0.6 0.6 {}
T {4C} 9950 -3390 0 0 0.6 0.6 {}
T {8C} 10030 -3390 0 0 0.6 0.6 {}
T {512C} 10170 -3390 0 0 0.6 0.6 {}
T {VDD} 9620 -3530 0 0 0.4 0.4 {}
T {vcm} 9620 -3510 0 0 0.4 0.4 {}
T {VSS} 9620 -3490 0 0 0.4 0.4 {}
T {VDD} 9620 -3130 2 1 0.4 0.4 {}
T {vcm} 9620 -3150 2 1 0.4 0.4 {}
T {VSS} 9620 -3170 2 1 0.4 0.4 {}
T {C0} 9710 -3310 0 0 0.6 0.6 {}
T {C} 9790 -3310 0 0 0.6 0.6 {}
T {2C} 9870 -3310 0 0 0.6 0.6 {}
T {4C} 9950 -3310 0 0 0.6 0.6 {}
T {8C} 10030 -3310 0 0 0.6 0.6 {}
T {1C+1023C thermometer-coded} 9740 -3550 0 0 0.4 0.4 {}
T {512C} 10170 -3310 0 0 0.6 0.6 {}
T {extra} 9720 -3420 0 0 0.2 0.2 {}
T {bin1} 9800 -3420 0 0 0.2 0.2 {}
T {bin2} 9880 -3420 0 0 0.2 0.2 {}
T {bin4} 9960 -3420 0 0 0.2 0.2 {}
T {waffle8} 10180 -3420 0 0 0.2 0.2 {}
T {waffle8} 10040 -3420 0 0 0.2 0.2 {}
T {extra} 9720 -3250 0 0 0.2 0.2 {}
T {bin1} 9800 -3250 0 0 0.2 0.2 {}
T {bin2} 9880 -3250 0 0 0.2 0.2 {}
T {bin4} 9960 -3250 0 0 0.2 0.2 {}
T {waffle8} 10180 -3250 0 0 0.2 0.2 {}
T {waffle8} 10040 -3250 0 0 0.2 0.2 {}
N 1790 -2980 1810 -2980 {
lab=VDD}
N 1790 -2960 1810 -2960 {
lab=VSS}
N 1790 -2940 1810 -2940 {
lab=sample}
N 1790 -2920 1810 -2920 {
lab=sample_n}
N 1790 -3000 1810 -3000 {
lab=VDD}
N 1850 -2840 1850 -2830 {
lab=VSS}
N 1930 -2840 1930 -2830 {
lab=VDD}
N 1950 -2840 1950 -2830 {
lab=VSS}
N 2170 -2840 2170 -2830 {
lab=VSS}
N 2250 -2840 2250 -2820 {
lab=col_n[0]}
N 2270 -2840 2270 -2820 {
lab=col[0]}
N 2500 -2840 2500 -2830 {
lab=VSS}
N 2580 -2840 2580 -2820 {
lab=col_n[1]}
N 2530 -2840 2530 -2830 {
lab=en_C0_n}
N 2530 -2830 2530 -2820 {
lab=en_C0_n}
N 2600 -2840 2600 -2820 {
lab=col[1]}
N 1850 -3160 1850 -3150 {
lab=VSS}
N 1850 -3460 1850 -3450 {
lab=VSS}
N 2170 -3460 2170 -3450 {
lab=VSS}
N 2170 -3160 2170 -3150 {
lab=VSS}
N 2500 -3160 2500 -3150 {
lab=VSS}
N 2500 -3460 2500 -3450 {
lab=VSS}
N 2850 -3460 2850 -3450 {
lab=VSS}
N 2850 -3160 2850 -3150 {
lab=VSS}
N 3200 -3160 3200 -3150 {
lab=VSS}
N 3200 -3460 3200 -3450 {
lab=VSS}
N 3550 -3460 3550 -3450 {
lab=VSS}
N 3890 -3460 3890 -3450 {
lab=VSS}
N 3890 -3160 3890 -3150 {
lab=VSS}
N 3550 -3160 3550 -3150 {
lab=VSS}
N 4240 -3460 4240 -3450 {
lab=VSS}
N 4240 -3160 4240 -3150 {
lab=VSS}
N 4600 -3460 4600 -3450 {
lab=VSS}
N 4930 -3460 4930 -3450 {
lab=VSS}
N 4600 -3160 4600 -3150 {
lab=VSS}
N 4930 -3160 4930 -3150 {
lab=VSS}
N 5260 -3160 5260 -3150 {
lab=VSS}
N 5260 -3460 5260 -3450 {
lab=VSS}
N 5610 -3460 5610 -3450 {
lab=VSS}
N 5960 -3460 5960 -3450 {
lab=VSS}
N 5610 -3160 5610 -3150 {
lab=VSS}
N 5960 -3160 5960 -3150 {
lab=VSS}
N 6300 -3460 6300 -3450 {
lab=VSS}
N 6300 -3160 6300 -3150 {
lab=VSS}
N 6640 -3460 6640 -3450 {
lab=VSS}
N 6640 -3160 6640 -3150 {
lab=VSS}
N 3200 -2840 3200 -2830 {
lab=VSS}
N 3280 -2840 3280 -2820 {
lab=col_n[3]}
N 3300 -2840 3300 -2820 {
lab=col[3]}
N 2850 -2840 2850 -2830 {
lab=VSS}
N 2930 -2840 2930 -2820 {
lab=col_n[2]}
N 2950 -2840 2950 -2820 {
lab=col[2]}
N 3550 -2840 3550 -2830 {
lab=VSS}
N 3630 -2840 3630 -2820 {
lab=col_n[4]}
N 3650 -2840 3650 -2820 {
lab=col[4]}
N 3890 -2840 3890 -2830 {
lab=VSS}
N 3970 -2840 3970 -2820 {
lab=col_n[5]}
N 3990 -2840 3990 -2820 {
lab=col[5]}
N 4240 -2840 4240 -2830 {
lab=VSS}
N 4320 -2840 4320 -2820 {
lab=col_n[6]}
N 4270 -2840 4270 -2820 {
lab=en_bit_n[1]}
N 4340 -2840 4340 -2820 {
lab=col[6]}
N 4600 -2840 4600 -2830 {
lab=VSS}
N 4680 -2840 4680 -2820 {
lab=col_n[7]}
N 4630 -2840 4630 -2820 {
lab=en_bit_n[2]}
N 4700 -2840 4700 -2820 {
lab=col[7]}
N 4930 -2840 4930 -2830 {
lab=VSS}
N 5010 -2840 5010 -2820 {
lab=col_n[8]}
N 4960 -2840 4960 -2820 {
lab=en_bit_n[0]}
N 5030 -2840 5030 -2820 {
lab=col[8]}
N 5340 -2840 5340 -2820 {
lab=col_n[9]}
N 5360 -2840 5360 -2820 {
lab=col[9]}
N 5260 -2840 5260 -2830 {lab=VSS}
N 5690 -2840 5690 -2820 {
lab=col_n[10]}
N 5710 -2840 5710 -2820 {
lab=col[10]}
N 5610 -2840 5610 -2830 {lab=VSS}
N 6040 -2840 6040 -2820 {
lab=col_n[11]}
N 6060 -2840 6060 -2820 {
lab=col[11]}
N 5960 -2840 5960 -2830 {lab=VSS}
N 6380 -2840 6380 -2820 {
lab=col_n[12]}
N 6400 -2840 6400 -2820 {
lab=col[12]}
N 6300 -2840 6300 -2830 {lab=VSS}
N 6640 -2840 6640 -2830 {
lab=VSS}
N 6360 -2840 6360 -2820 {
lab=sw}
N 6440 -2840 6440 -2820 {
lab=sw_n}
N 6420 -2840 6420 -2820 {
lab=analog_in}
N 6720 -2840 6720 -2820 {
lab=VDD}
N 6740 -2840 6740 -2820 {
lab=VSS}
N 1870 -3080 1870 -3060 {
lab=vcm}
N 1850 -3070 1850 -3060 {
lab=VDD}
N 1910 -3080 1910 -3060 {
lab=ctop}
N 2190 -3080 2190 -3060 {
lab=vcm}
N 2170 -3070 2170 -3060 {
lab=VDD}
N 2230 -3080 2230 -3060 {
lab=ctop}
N 2520 -3080 2520 -3060 {
lab=vcm}
N 2500 -3070 2500 -3060 {
lab=VDD}
N 2560 -3080 2560 -3060 {
lab=ctop}
N 2870 -3080 2870 -3060 {
lab=vcm}
N 2850 -3070 2850 -3060 {
lab=VDD}
N 2910 -3080 2910 -3060 {
lab=ctop}
N 3220 -3080 3220 -3060 {
lab=vcm}
N 3200 -3070 3200 -3060 {
lab=VDD}
N 3260 -3080 3260 -3060 {
lab=ctop}
N 3570 -3080 3570 -3060 {
lab=vcm}
N 3550 -3070 3550 -3060 {
lab=VDD}
N 3610 -3080 3610 -3060 {
lab=ctop}
N 3910 -3080 3910 -3060 {
lab=vcm}
N 3890 -3070 3890 -3060 {
lab=VDD}
N 3950 -3080 3950 -3060 {
lab=ctop}
N 4260 -3080 4260 -3060 {
lab=vcm}
N 4240 -3070 4240 -3060 {
lab=VDD}
N 4300 -3080 4300 -3060 {
lab=ctop}
N 4620 -3080 4620 -3060 {
lab=vcm}
N 4600 -3070 4600 -3060 {
lab=VDD}
N 4660 -3080 4660 -3060 {
lab=ctop}
N 4950 -3080 4950 -3060 {
lab=vcm}
N 4930 -3070 4930 -3060 {
lab=VDD}
N 4990 -3080 4990 -3060 {
lab=ctop}
N 5280 -3080 5280 -3060 {
lab=vcm}
N 5260 -3070 5260 -3060 {
lab=VDD}
N 5320 -3080 5320 -3060 {
lab=ctop}
N 5630 -3080 5630 -3060 {
lab=vcm}
N 5610 -3070 5610 -3060 {
lab=VDD}
N 5670 -3080 5670 -3060 {
lab=ctop}
N 5980 -3080 5980 -3060 {
lab=vcm}
N 5960 -3070 5960 -3060 {
lab=VDD}
N 6020 -3080 6020 -3060 {
lab=ctop}
N 6320 -3080 6320 -3060 {
lab=vcm}
N 6300 -3070 6300 -3060 {
lab=VDD}
N 6360 -3080 6360 -3060 {
lab=ctop}
N 6660 -3080 6660 -3060 {
lab=vcm}
N 6640 -3070 6640 -3060 {
lab=VDD}
N 6700 -3080 6700 -3060 {
lab=ctop}
N 6660 -3400 6660 -3380 {
lab=vcm}
N 6640 -3390 6640 -3380 {
lab=VDD}
N 6700 -3400 6700 -3380 {
lab=ctop}
N 6660 -3700 6660 -3680 {
lab=vcm}
N 6640 -3690 6640 -3680 {
lab=VDD}
N 6700 -3700 6700 -3680 {
lab=ctop}
N 5980 -3700 5980 -3680 {
lab=vcm}
N 5960 -3690 5960 -3680 {
lab=VDD}
N 6020 -3700 6020 -3680 {
lab=ctop}
N 6320 -3700 6320 -3680 {
lab=vcm}
N 6300 -3690 6300 -3680 {
lab=VDD}
N 6360 -3700 6360 -3680 {
lab=ctop}
N 6320 -3400 6320 -3380 {
lab=vcm}
N 6300 -3390 6300 -3380 {
lab=VDD}
N 6360 -3400 6360 -3380 {
lab=ctop}
N 5980 -3400 5980 -3380 {
lab=vcm}
N 5960 -3390 5960 -3380 {
lab=VDD}
N 6020 -3400 6020 -3380 {
lab=ctop}
N 5630 -3400 5630 -3380 {
lab=vcm}
N 5610 -3390 5610 -3380 {
lab=VDD}
N 5670 -3400 5670 -3380 {
lab=ctop}
N 5630 -3700 5630 -3680 {
lab=vcm}
N 5610 -3690 5610 -3680 {
lab=VDD}
N 5670 -3700 5670 -3680 {
lab=ctop}
N 5280 -3700 5280 -3680 {
lab=vcm}
N 5260 -3690 5260 -3680 {
lab=VDD}
N 5320 -3700 5320 -3680 {
lab=ctop}
N 5280 -3400 5280 -3380 {
lab=vcm}
N 5260 -3390 5260 -3380 {
lab=VDD}
N 5320 -3400 5320 -3380 {
lab=ctop}
N 4950 -3400 4950 -3380 {
lab=vcm}
N 4930 -3390 4930 -3380 {
lab=VDD}
N 4990 -3400 4990 -3380 {
lab=ctop}
N 4950 -3700 4950 -3680 {
lab=vcm}
N 4930 -3690 4930 -3680 {
lab=VDD}
N 4990 -3700 4990 -3680 {
lab=ctop}
N 4620 -3700 4620 -3680 {
lab=vcm}
N 4600 -3690 4600 -3680 {
lab=VDD}
N 4660 -3700 4660 -3680 {
lab=ctop}
N 4620 -3400 4620 -3380 {
lab=vcm}
N 4600 -3390 4600 -3380 {
lab=VDD}
N 4660 -3400 4660 -3380 {
lab=ctop}
N 4260 -3400 4260 -3380 {
lab=vcm}
N 4240 -3390 4240 -3380 {
lab=VDD}
N 4300 -3400 4300 -3380 {
lab=ctop}
N 4260 -3700 4260 -3680 {
lab=vcm}
N 4240 -3690 4240 -3680 {
lab=VDD}
N 4300 -3700 4300 -3680 {
lab=ctop}
N 3910 -3700 3910 -3680 {
lab=vcm}
N 3890 -3690 3890 -3680 {
lab=VDD}
N 3950 -3700 3950 -3680 {
lab=ctop}
N 3910 -3400 3910 -3380 {
lab=vcm}
N 3890 -3390 3890 -3380 {
lab=VDD}
N 3950 -3400 3950 -3380 {
lab=ctop}
N 3570 -3400 3570 -3380 {
lab=vcm}
N 3550 -3390 3550 -3380 {
lab=VDD}
N 3610 -3400 3610 -3380 {
lab=ctop}
N 3570 -3700 3570 -3680 {
lab=vcm}
N 3550 -3690 3550 -3680 {
lab=VDD}
N 3610 -3700 3610 -3680 {
lab=ctop}
N 3220 -3700 3220 -3680 {
lab=vcm}
N 3200 -3690 3200 -3680 {
lab=VDD}
N 3260 -3700 3260 -3680 {
lab=ctop}
N 3220 -3400 3220 -3380 {
lab=vcm}
N 3200 -3390 3200 -3380 {
lab=VDD}
N 3260 -3400 3260 -3380 {
lab=ctop}
N 2870 -3400 2870 -3380 {
lab=vcm}
N 2850 -3390 2850 -3380 {
lab=VDD}
N 2910 -3400 2910 -3380 {
lab=ctop}
N 2870 -3700 2870 -3680 {
lab=vcm}
N 2850 -3690 2850 -3680 {
lab=VDD}
N 2910 -3700 2910 -3680 {
lab=ctop}
N 2520 -3700 2520 -3680 {
lab=vcm}
N 2500 -3690 2500 -3680 {
lab=VDD}
N 2560 -3700 2560 -3680 {
lab=ctop}
N 2190 -3700 2190 -3680 {
lab=vcm}
N 2170 -3690 2170 -3680 {
lab=VDD}
N 2230 -3700 2230 -3680 {
lab=ctop}
N 2190 -3400 2190 -3380 {
lab=vcm}
N 2170 -3390 2170 -3380 {
lab=VDD}
N 2230 -3400 2230 -3380 {
lab=ctop}
N 2520 -3400 2520 -3380 {
lab=vcm}
N 2500 -3390 2500 -3380 {
lab=VDD}
N 2560 -3400 2560 -3380 {
lab=ctop}
N 1870 -3700 1870 -3680 {
lab=vcm}
N 1850 -3690 1850 -3680 {
lab=VDD}
N 1910 -3700 1910 -3680 {
lab=ctop}
N 1870 -3400 1870 -3380 {
lab=vcm}
N 1850 -3390 1850 -3380 {
lab=VDD}
N 1910 -3400 1910 -3380 {
lab=ctop}
N 1790 -3240 1810 -3240 {
lab=sample_n}
N 1790 -3260 1810 -3260 {
lab=sample}
N 1790 -3280 1810 -3280 {
lab=rowon_n[0]}
N 1790 -3300 1810 -3300 {
lab=row_n[0]}
N 1790 -3320 1810 -3320 {
lab=rowoff_n[0]}
N 1790 -3540 1810 -3540 {
lab=sample_n}
N 1790 -3560 1810 -3560 {
lab=sample}
N 1790 -3580 1810 -3580 {
lab=rowon_n[1]}
N 1790 -3600 1810 -3600 {
lab=row_n[1]}
N 1790 -3620 1810 -3620 {
lab=rowoff_n[1]}
N 2030 -3560 2130 -3560 {lab=#net1}
N 2030 -3540 2130 -3540 {lab=#net2}
N 1810 -3620 1820 -3630 {lab=rowoff_n[1]}
N 1820 -3630 2040 -3630 {lab=rowoff_n[1]}
N 2040 -3630 2050 -3620 {lab=rowoff_n[1]}
N 2050 -3620 2130 -3620 {lab=rowoff_n[1]}
N 1810 -3600 1820 -3610 {lab=row_n[1]}
N 1820 -3610 2040 -3610 {lab=row_n[1]}
N 2040 -3610 2050 -3600 {lab=row_n[1]}
N 2050 -3600 2130 -3600 {lab=row_n[1]}
N 1810 -3580 1820 -3590 {lab=rowon_n[1]}
N 1820 -3590 2040 -3590 {lab=rowon_n[1]}
N 2040 -3590 2050 -3580 {lab=rowon_n[1]}
N 2050 -3580 2130 -3580 {lab=rowon_n[1]}
N 2130 -3620 2140 -3630 {lab=rowoff_n[1]}
N 2130 -3600 2140 -3610 {lab=row_n[1]}
N 2140 -3610 2340 -3610 {lab=row_n[1]}
N 2340 -3610 2350 -3600 {lab=row_n[1]}
N 2350 -3600 2460 -3600 {lab=row_n[1]}
N 2140 -3630 2340 -3630 {lab=rowoff_n[1]}
N 2340 -3630 2350 -3620 {lab=rowoff_n[1]}
N 2350 -3620 2460 -3620 {lab=rowoff_n[1]}
N 2130 -3580 2140 -3590 {lab=rowon_n[1]}
N 2140 -3590 2340 -3590 {lab=rowon_n[1]}
N 2340 -3590 2350 -3580 {lab=rowon_n[1]}
N 2350 -3580 2460 -3580 {lab=rowon_n[1]}
N 2130 -3560 2140 -3570 {lab=#net1}
N 2140 -3570 2340 -3570 {lab=#net1}
N 2340 -3570 2350 -3560 {lab=#net1}
N 2350 -3560 2460 -3560 {lab=#net1}
N 2130 -3540 2140 -3550 {lab=#net2}
N 2140 -3550 2340 -3550 {lab=#net2}
N 2340 -3550 2350 -3540 {lab=#net2}
N 2350 -3540 2460 -3540 {lab=#net2}
N 2460 -3600 2470 -3610 {lab=row_n[1]}
N 2470 -3610 2670 -3610 {lab=row_n[1]}
N 2670 -3610 2680 -3600 {lab=row_n[1]}
N 2680 -3600 2810 -3600 {lab=row_n[1]}
N 2460 -3580 2470 -3590 {lab=rowon_n[1]}
N 2470 -3590 2670 -3590 {lab=rowon_n[1]}
N 2670 -3590 2680 -3580 {lab=rowon_n[1]}
N 2680 -3580 2810 -3580 {lab=rowon_n[1]}
N 2460 -3560 2470 -3570 {lab=#net1}
N 2470 -3570 2670 -3570 {lab=#net1}
N 2670 -3570 2680 -3560 {lab=#net1}
N 2680 -3560 2810 -3560 {lab=#net1}
N 2460 -3540 2480 -3550 {lab=#net2}
N 2480 -3550 2670 -3550 {lab=#net2}
N 2670 -3550 2680 -3540 {lab=#net2}
N 2680 -3540 2810 -3540 {lab=#net2}
N 2460 -3620 2470 -3630 {lab=rowoff_n[1]}
N 2470 -3630 2670 -3630 {lab=rowoff_n[1]}
N 2670 -3630 2680 -3620 {lab=rowoff_n[1]}
N 2680 -3620 2810 -3620 {lab=rowoff_n[1]}
N 2810 -3620 2820 -3630 {lab=rowoff_n[1]}
N 2820 -3630 3020 -3630 {lab=rowoff_n[1]}
N 3020 -3630 3030 -3620 {lab=rowoff_n[1]}
N 3030 -3620 3160 -3620 {lab=rowoff_n[1]}
N 2810 -3600 2820 -3610 {lab=row_n[1]}
N 2820 -3610 3020 -3610 {lab=row_n[1]}
N 3020 -3610 3030 -3600 {lab=row_n[1]}
N 3030 -3600 3160 -3600 {lab=row_n[1]}
N 2810 -3580 2820 -3590 {lab=rowon_n[1]}
N 2820 -3590 3020 -3590 {lab=rowon_n[1]}
N 3020 -3590 3030 -3580 {lab=rowon_n[1]}
N 3030 -3580 3160 -3580 {lab=rowon_n[1]}
N 2810 -3560 2820 -3570 {lab=#net1}
N 2820 -3570 3020 -3570 {lab=#net1}
N 3020 -3570 3030 -3560 {lab=#net1}
N 3030 -3560 3160 -3560 {lab=#net1}
N 2810 -3540 2820 -3550 {lab=#net2}
N 2820 -3550 3020 -3550 {lab=#net2}
N 3020 -3550 3030 -3540 {lab=#net2}
N 3030 -3540 3160 -3540 {lab=#net2}
N 3160 -3620 3170 -3630 {lab=rowoff_n[1]}
N 3170 -3630 3370 -3630 {lab=rowoff_n[1]}
N 3370 -3630 3380 -3620 {lab=rowoff_n[1]}
N 3380 -3620 3510 -3620 {lab=rowoff_n[1]}
N 3160 -3600 3170 -3610 {lab=row_n[1]}
N 3170 -3610 3370 -3610 {lab=row_n[1]}
N 3370 -3610 3380 -3600 {lab=row_n[1]}
N 3380 -3600 3510 -3600 {lab=row_n[1]}
N 3160 -3580 3170 -3590 {lab=rowon_n[1]}
N 3170 -3590 3370 -3590 {lab=rowon_n[1]}
N 3370 -3590 3380 -3580 {lab=rowon_n[1]}
N 3380 -3580 3510 -3580 {lab=rowon_n[1]}
N 3370 -3570 3380 -3560 {lab=#net1}
N 3380 -3560 3510 -3560 {lab=#net1}
N 3160 -3540 3170 -3550 {lab=#net2}
N 3170 -3550 3370 -3550 {lab=#net2}
N 3370 -3550 3380 -3540 {lab=#net2}
N 3380 -3540 3510 -3540 {lab=#net2}
N 3160 -3560 3170 -3570 {lab=#net1}
N 3170 -3570 3370 -3570 {lab=#net1}
N 3510 -3620 3520 -3630 {lab=rowoff_n[1]}
N 3520 -3630 3720 -3630 {lab=rowoff_n[1]}
N 3720 -3630 3730 -3620 {lab=rowoff_n[1]}
N 3730 -3620 3850 -3620 {lab=rowoff_n[1]}
N 3510 -3600 3520 -3610 {lab=row_n[1]}
N 3520 -3610 3720 -3610 {lab=row_n[1]}
N 3720 -3610 3730 -3600 {lab=row_n[1]}
N 3730 -3600 3850 -3600 {lab=row_n[1]}
N 3510 -3580 3520 -3590 {lab=rowon_n[1]}
N 3520 -3590 3720 -3590 {lab=rowon_n[1]}
N 3720 -3590 3730 -3580 {lab=rowon_n[1]}
N 3730 -3580 3850 -3580 {lab=rowon_n[1]}
N 3510 -3560 3520 -3570 {lab=#net1}
N 3520 -3570 3720 -3570 {lab=#net1}
N 3720 -3570 3730 -3560 {lab=#net1}
N 3730 -3560 3850 -3560 {lab=#net1}
N 3510 -3540 3520 -3550 {lab=#net2}
N 3520 -3550 3720 -3550 {lab=#net2}
N 3720 -3550 3730 -3540 {lab=#net2}
N 3730 -3540 3850 -3540 {lab=#net2}
N 3850 -3620 3860 -3630 {lab=rowoff_n[1]}
N 3860 -3630 4060 -3630 {lab=rowoff_n[1]}
N 4060 -3630 4070 -3620 {lab=rowoff_n[1]}
N 4070 -3620 4200 -3620 {lab=rowoff_n[1]}
N 3850 -3600 3860 -3610 {lab=row_n[1]}
N 3860 -3610 4060 -3610 {lab=row_n[1]}
N 4060 -3610 4070 -3600 {lab=row_n[1]}
N 4070 -3600 4200 -3600 {lab=row_n[1]}
N 3850 -3580 3860 -3590 {lab=rowon_n[1]}
N 3860 -3590 4060 -3590 {lab=rowon_n[1]}
N 4060 -3590 4070 -3580 {lab=rowon_n[1]}
N 4070 -3580 4200 -3580 {lab=rowon_n[1]}
N 3850 -3560 3860 -3570 {lab=#net1}
N 3860 -3570 4060 -3570 {lab=#net1}
N 3850 -3540 3860 -3550 {lab=#net2}
N 3860 -3550 4060 -3550 {lab=#net2}
N 4060 -3550 4070 -3540 {lab=#net2}
N 4070 -3540 4200 -3540 {lab=#net2}
N 4060 -3570 4070 -3560 {lab=#net1}
N 4070 -3560 4200 -3560 {lab=#net1}
N 4200 -3620 4210 -3630 {lab=rowoff_n[1]}
N 4210 -3630 4410 -3630 {lab=rowoff_n[1]}
N 4410 -3630 4420 -3620 {lab=rowoff_n[1]}
N 4420 -3620 4560 -3620 {lab=rowoff_n[1]}
N 4200 -3600 4210 -3610 {lab=row_n[1]}
N 4210 -3610 4410 -3610 {lab=row_n[1]}
N 4410 -3610 4420 -3600 {lab=row_n[1]}
N 4420 -3600 4560 -3600 {lab=row_n[1]}
N 4200 -3580 4210 -3590 {lab=rowon_n[1]}
N 4210 -3590 4410 -3590 {lab=rowon_n[1]}
N 4410 -3590 4420 -3580 {lab=rowon_n[1]}
N 4420 -3580 4560 -3580 {lab=rowon_n[1]}
N 4200 -3560 4210 -3570 {lab=#net1}
N 4210 -3570 4410 -3570 {lab=#net1}
N 4410 -3570 4420 -3560 {lab=#net1}
N 4420 -3560 4560 -3560 {lab=#net1}
N 4200 -3540 4210 -3550 {lab=#net2}
N 4210 -3550 4410 -3550 {lab=#net2}
N 4410 -3550 4420 -3540 {lab=#net2}
N 4420 -3540 4560 -3540 {lab=#net2}
N 4560 -3620 4570 -3630 {lab=rowoff_n[1]}
N 4570 -3630 4770 -3630 {lab=rowoff_n[1]}
N 4770 -3630 4780 -3620 {lab=rowoff_n[1]}
N 4780 -3620 4890 -3620 {lab=rowoff_n[1]}
N 4560 -3600 4570 -3610 {lab=row_n[1]}
N 4570 -3610 4770 -3610 {lab=row_n[1]}
N 4770 -3610 4780 -3600 {lab=row_n[1]}
N 4780 -3600 4890 -3600 {lab=row_n[1]}
N 4560 -3580 4570 -3590 {lab=rowon_n[1]}
N 4570 -3590 4770 -3590 {lab=rowon_n[1]}
N 4770 -3590 4780 -3580 {lab=rowon_n[1]}
N 4780 -3580 4890 -3580 {lab=rowon_n[1]}
N 4560 -3560 4570 -3570 {lab=#net1}
N 4570 -3570 4770 -3570 {lab=#net1}
N 4770 -3570 4780 -3560 {lab=#net1}
N 4780 -3560 4890 -3560 {lab=#net1}
N 4560 -3540 4570 -3550 {lab=#net2}
N 4570 -3550 4770 -3550 {lab=#net2}
N 4770 -3550 4780 -3540 {lab=#net2}
N 4780 -3540 4890 -3540 {lab=#net2}
N 4890 -3620 4900 -3630 {lab=rowoff_n[1]}
N 4900 -3630 5100 -3630 {lab=rowoff_n[1]}
N 5100 -3630 5110 -3620 {lab=rowoff_n[1]}
N 5110 -3620 5220 -3620 {lab=rowoff_n[1]}
N 4890 -3600 4900 -3610 {lab=row_n[1]}
N 4900 -3610 5100 -3610 {lab=row_n[1]}
N 5100 -3610 5110 -3600 {lab=row_n[1]}
N 5110 -3600 5220 -3600 {lab=row_n[1]}
N 4890 -3580 4900 -3590 {lab=rowon_n[1]}
N 4900 -3590 5100 -3590 {lab=rowon_n[1]}
N 5100 -3590 5110 -3580 {lab=rowon_n[1]}
N 5110 -3580 5220 -3580 {lab=rowon_n[1]}
N 4890 -3560 4900 -3570 {lab=#net1}
N 4900 -3570 5100 -3570 {lab=#net1}
N 5100 -3570 5110 -3560 {lab=#net1}
N 5110 -3560 5220 -3560 {lab=#net1}
N 4890 -3540 4900 -3550 {lab=#net2}
N 4900 -3550 5100 -3550 {lab=#net2}
N 5100 -3550 5120 -3540 {lab=#net2}
N 5120 -3540 5220 -3540 {lab=#net2}
N 5220 -3620 5230 -3630 {lab=rowoff_n[1]}
N 5230 -3630 5430 -3630 {lab=rowoff_n[1]}
N 5430 -3630 5440 -3620 {lab=rowoff_n[1]}
N 5440 -3620 5570 -3620 {lab=rowoff_n[1]}
N 5220 -3600 5230 -3610 {lab=row_n[1]}
N 5230 -3610 5430 -3610 {lab=row_n[1]}
N 5430 -3610 5440 -3600 {lab=row_n[1]}
N 5440 -3600 5570 -3600 {lab=row_n[1]}
N 5220 -3580 5230 -3590 {lab=rowon_n[1]}
N 5230 -3590 5430 -3590 {lab=rowon_n[1]}
N 5430 -3590 5440 -3580 {lab=rowon_n[1]}
N 5440 -3580 5570 -3580 {lab=rowon_n[1]}
N 5220 -3560 5230 -3570 {lab=#net1}
N 5230 -3570 5430 -3570 {lab=#net1}
N 5430 -3570 5440 -3560 {lab=#net1}
N 5440 -3560 5570 -3560 {lab=#net1}
N 5220 -3540 5230 -3550 {lab=#net2}
N 5230 -3550 5430 -3550 {lab=#net2}
N 5430 -3550 5440 -3540 {lab=#net2}
N 5440 -3540 5570 -3540 {lab=#net2}
N 5570 -3620 5580 -3630 {lab=rowoff_n[1]}
N 5580 -3630 5780 -3630 {lab=rowoff_n[1]}
N 5780 -3630 5790 -3620 {lab=rowoff_n[1]}
N 5790 -3620 5920 -3620 {lab=rowoff_n[1]}
N 5570 -3600 5580 -3610 {lab=row_n[1]}
N 5580 -3610 5780 -3610 {lab=row_n[1]}
N 5570 -3580 5580 -3590 {lab=rowon_n[1]}
N 5580 -3590 5780 -3590 {lab=rowon_n[1]}
N 5780 -3590 5790 -3580 {lab=rowon_n[1]}
N 5790 -3580 5920 -3580 {lab=rowon_n[1]}
N 5780 -3610 5790 -3600 {lab=row_n[1]}
N 5790 -3600 5920 -3600 {lab=row_n[1]}
N 5570 -3560 5580 -3570 {lab=#net1}
N 5580 -3570 5780 -3570 {lab=#net1}
N 5780 -3570 5790 -3560 {lab=#net1}
N 5790 -3560 5920 -3560 {lab=#net1}
N 5570 -3540 5580 -3550 {lab=#net2}
N 5580 -3550 5780 -3550 {lab=#net2}
N 5780 -3550 5790 -3540 {lab=#net2}
N 5790 -3540 5920 -3540 {lab=#net2}
N 5920 -3620 5930 -3630 {lab=rowoff_n[1]}
N 5930 -3630 6130 -3630 {lab=rowoff_n[1]}
N 6130 -3630 6140 -3620 {lab=rowoff_n[1]}
N 6140 -3620 6260 -3620 {lab=rowoff_n[1]}
N 5920 -3600 5930 -3610 {lab=row_n[1]}
N 5930 -3610 6130 -3610 {lab=row_n[1]}
N 6130 -3610 6140 -3600 {lab=row_n[1]}
N 6140 -3600 6260 -3600 {lab=row_n[1]}
N 5920 -3580 5930 -3590 {lab=rowon_n[1]}
N 5930 -3590 6130 -3590 {lab=rowon_n[1]}
N 6130 -3590 6140 -3580 {lab=rowon_n[1]}
N 6140 -3580 6260 -3580 {lab=rowon_n[1]}
N 5920 -3560 5930 -3570 {lab=#net1}
N 5930 -3570 6130 -3570 {lab=#net1}
N 6130 -3570 6140 -3560 {lab=#net1}
N 6140 -3560 6260 -3560 {lab=#net1}
N 5920 -3540 5930 -3550 {lab=#net2}
N 5930 -3550 6130 -3550 {lab=#net2}
N 6130 -3550 6140 -3540 {lab=#net2}
N 6140 -3540 6260 -3540 {lab=#net2}
N 6260 -3620 6270 -3630 {lab=rowoff_n[1]}
N 6270 -3630 6470 -3630 {lab=rowoff_n[1]}
N 6470 -3630 6480 -3620 {lab=rowoff_n[1]}
N 6480 -3620 6600 -3620 {lab=rowoff_n[1]}
N 6260 -3600 6270 -3610 {lab=row_n[1]}
N 6270 -3610 6470 -3610 {lab=row_n[1]}
N 6470 -3610 6480 -3600 {lab=row_n[1]}
N 6480 -3600 6600 -3600 {lab=row_n[1]}
N 6260 -3580 6270 -3590 {lab=rowon_n[1]}
N 6270 -3590 6470 -3590 {lab=rowon_n[1]}
N 6470 -3590 6480 -3580 {lab=rowon_n[1]}
N 6480 -3580 6600 -3580 {lab=rowon_n[1]}
N 6260 -3560 6270 -3570 {lab=#net1}
N 6270 -3570 6470 -3570 {lab=#net1}
N 6470 -3570 6480 -3560 {lab=#net1}
N 6480 -3560 6600 -3560 {lab=#net1}
N 6260 -3540 6270 -3550 {lab=#net2}
N 6270 -3550 6470 -3550 {lab=#net2}
N 6470 -3550 6490 -3540 {lab=#net2}
N 6490 -3540 6600 -3540 {lab=#net2}
N 6600 -3620 6610 -3630 {lab=rowoff_n[1]}
N 6610 -3630 6810 -3630 {lab=rowoff_n[1]}
N 6600 -3600 6610 -3610 {lab=row_n[1]}
N 6610 -3610 6810 -3610 {lab=row_n[1]}
N 6810 -3610 6820 -3600 {lab=row_n[1]}
N 6810 -3630 6820 -3620 {lab=rowoff_n[1]}
N 6600 -3580 6610 -3590 {lab=rowon_n[1]}
N 6610 -3590 6810 -3590 {lab=rowon_n[1]}
N 6600 -3560 6610 -3570 {lab=#net1}
N 6610 -3570 6810 -3570 {lab=#net1}
N 6810 -3570 6820 -3560 {lab=#net1}
N 6600 -3540 6610 -3550 {lab=#net2}
N 6610 -3550 6810 -3550 {lab=#net2}
N 6810 -3550 6820 -3540 {lab=#net2}
N 6810 -3590 6820 -3580 {lab=rowon_n[1]}
N 1850 -3790 1850 -3780 {
lab=VSS}
N 2170 -3790 2170 -3780 {
lab=VSS}
N 2500 -3790 2500 -3780 {
lab=VSS}
N 2850 -3790 2850 -3780 {
lab=VSS}
N 3200 -3790 3200 -3780 {
lab=VSS}
N 3550 -3790 3550 -3780 {
lab=VSS}
N 3890 -3790 3890 -3780 {
lab=VSS}
N 4240 -3790 4240 -3780 {
lab=VSS}
N 4600 -3790 4600 -3780 {
lab=VSS}
N 4930 -3790 4930 -3780 {
lab=VSS}
N 5260 -3790 5260 -3780 {
lab=VSS}
N 5610 -3790 5610 -3780 {
lab=VSS}
N 5960 -3790 5960 -3780 {
lab=VSS}
N 6300 -3790 6300 -3780 {
lab=VSS}
N 6640 -3790 6640 -3780 {
lab=VSS}
N 6660 -4030 6660 -4010 {
lab=vcm}
N 6640 -4020 6640 -4010 {
lab=VDD}
N 6700 -4030 6700 -4010 {
lab=ctop}
N 5980 -4030 5980 -4010 {
lab=vcm}
N 5960 -4020 5960 -4010 {
lab=VDD}
N 6020 -4030 6020 -4010 {
lab=ctop}
N 6320 -4030 6320 -4010 {
lab=vcm}
N 6300 -4020 6300 -4010 {
lab=VDD}
N 6360 -4030 6360 -4010 {
lab=ctop}
N 5630 -4030 5630 -4010 {
lab=vcm}
N 5610 -4020 5610 -4010 {
lab=VDD}
N 5670 -4030 5670 -4010 {
lab=ctop}
N 5280 -4030 5280 -4010 {
lab=vcm}
N 5260 -4020 5260 -4010 {
lab=VDD}
N 5320 -4030 5320 -4010 {
lab=ctop}
N 4950 -4030 4950 -4010 {
lab=vcm}
N 4930 -4020 4930 -4010 {
lab=VDD}
N 4990 -4030 4990 -4010 {
lab=ctop}
N 4620 -4030 4620 -4010 {
lab=vcm}
N 4600 -4020 4600 -4010 {
lab=VDD}
N 4660 -4030 4660 -4010 {
lab=ctop}
N 4260 -4030 4260 -4010 {
lab=vcm}
N 4240 -4020 4240 -4010 {
lab=VDD}
N 4300 -4030 4300 -4010 {
lab=ctop}
N 3910 -4030 3910 -4010 {
lab=vcm}
N 3890 -4020 3890 -4010 {
lab=VDD}
N 3950 -4030 3950 -4010 {
lab=ctop}
N 3570 -4030 3570 -4010 {
lab=vcm}
N 3550 -4020 3550 -4010 {
lab=VDD}
N 3610 -4030 3610 -4010 {
lab=ctop}
N 3220 -4030 3220 -4010 {
lab=vcm}
N 3200 -4020 3200 -4010 {
lab=VDD}
N 3260 -4030 3260 -4010 {
lab=ctop}
N 2870 -4030 2870 -4010 {
lab=vcm}
N 2850 -4020 2850 -4010 {
lab=VDD}
N 2910 -4030 2910 -4010 {
lab=ctop}
N 2520 -4030 2520 -4010 {
lab=vcm}
N 2500 -4020 2500 -4010 {
lab=VDD}
N 2560 -4030 2560 -4010 {
lab=ctop}
N 2190 -4030 2190 -4010 {
lab=vcm}
N 2170 -4020 2170 -4010 {
lab=VDD}
N 2230 -4030 2230 -4010 {
lab=ctop}
N 1870 -4030 1870 -4010 {
lab=vcm}
N 1850 -4020 1850 -4010 {
lab=VDD}
N 1910 -4030 1910 -4010 {
lab=ctop}
N 1790 -3870 1810 -3870 {
lab=sample_n}
N 1790 -3890 1810 -3890 {
lab=sample}
N 1790 -3910 1810 -3910 {
lab=rowon_n[2]}
N 1790 -3930 1810 -3930 {
lab=row_n[2]}
N 1790 -3950 1810 -3950 {
lab=rowoff_n[2]}
N 2030 -3890 2130 -3890 {lab=#net3}
N 2030 -3870 2130 -3870 {lab=#net4}
N 1810 -3950 1820 -3960 {lab=rowoff_n[2]}
N 1820 -3960 2040 -3960 {lab=rowoff_n[2]}
N 2040 -3960 2050 -3950 {lab=rowoff_n[2]}
N 2050 -3950 2130 -3950 {lab=rowoff_n[2]}
N 1810 -3930 1820 -3940 {lab=row_n[2]}
N 1820 -3940 2040 -3940 {lab=row_n[2]}
N 2040 -3940 2050 -3930 {lab=row_n[2]}
N 2050 -3930 2130 -3930 {lab=row_n[2]}
N 1810 -3910 1820 -3920 {lab=rowon_n[2]}
N 1820 -3920 2040 -3920 {lab=rowon_n[2]}
N 2040 -3920 2050 -3910 {lab=rowon_n[2]}
N 2050 -3910 2130 -3910 {lab=rowon_n[2]}
N 2130 -3950 2140 -3960 {lab=rowoff_n[2]}
N 2130 -3930 2140 -3940 {lab=row_n[2]}
N 2140 -3940 2340 -3940 {lab=row_n[2]}
N 2340 -3940 2350 -3930 {lab=row_n[2]}
N 2350 -3930 2460 -3930 {lab=row_n[2]}
N 2140 -3960 2340 -3960 {lab=rowoff_n[2]}
N 2340 -3960 2350 -3950 {lab=rowoff_n[2]}
N 2350 -3950 2460 -3950 {lab=rowoff_n[2]}
N 2130 -3910 2140 -3920 {lab=rowon_n[2]}
N 2140 -3920 2340 -3920 {lab=rowon_n[2]}
N 2340 -3920 2350 -3910 {lab=rowon_n[2]}
N 2350 -3910 2460 -3910 {lab=rowon_n[2]}
N 2130 -3890 2140 -3900 {lab=#net3}
N 2140 -3900 2340 -3900 {lab=#net3}
N 2340 -3900 2350 -3890 {lab=#net3}
N 2350 -3890 2460 -3890 {lab=#net3}
N 2130 -3870 2140 -3880 {lab=#net4}
N 2140 -3880 2340 -3880 {lab=#net4}
N 2340 -3880 2350 -3870 {lab=#net4}
N 2350 -3870 2460 -3870 {lab=#net4}
N 2460 -3930 2470 -3940 {lab=row_n[2]}
N 2470 -3940 2670 -3940 {lab=row_n[2]}
N 2670 -3940 2680 -3930 {lab=row_n[2]}
N 2680 -3930 2810 -3930 {lab=row_n[2]}
N 2460 -3910 2470 -3920 {lab=rowon_n[2]}
N 2470 -3920 2670 -3920 {lab=rowon_n[2]}
N 2670 -3920 2680 -3910 {lab=rowon_n[2]}
N 2680 -3910 2810 -3910 {lab=rowon_n[2]}
N 2460 -3890 2470 -3900 {lab=#net3}
N 2470 -3900 2670 -3900 {lab=#net3}
N 2670 -3900 2680 -3890 {lab=#net3}
N 2680 -3890 2810 -3890 {lab=#net3}
N 2460 -3870 2480 -3880 {lab=#net4}
N 2480 -3880 2670 -3880 {lab=#net4}
N 2670 -3880 2680 -3870 {lab=#net4}
N 2680 -3870 2810 -3870 {lab=#net4}
N 2460 -3950 2470 -3960 {lab=rowoff_n[2]}
N 2470 -3960 2670 -3960 {lab=rowoff_n[2]}
N 2670 -3960 2680 -3950 {lab=rowoff_n[2]}
N 2680 -3950 2810 -3950 {lab=rowoff_n[2]}
N 2810 -3950 2820 -3960 {lab=rowoff_n[2]}
N 2820 -3960 3020 -3960 {lab=rowoff_n[2]}
N 3020 -3960 3030 -3950 {lab=rowoff_n[2]}
N 3030 -3950 3160 -3950 {lab=rowoff_n[2]}
N 2810 -3930 2820 -3940 {lab=row_n[2]}
N 2820 -3940 3020 -3940 {lab=row_n[2]}
N 3020 -3940 3030 -3930 {lab=row_n[2]}
N 3030 -3930 3160 -3930 {lab=row_n[2]}
N 2810 -3910 2820 -3920 {lab=rowon_n[2]}
N 2820 -3920 3020 -3920 {lab=rowon_n[2]}
N 3020 -3920 3030 -3910 {lab=rowon_n[2]}
N 3030 -3910 3160 -3910 {lab=rowon_n[2]}
N 2810 -3890 2820 -3900 {lab=#net3}
N 2820 -3900 3020 -3900 {lab=#net3}
N 3020 -3900 3030 -3890 {lab=#net3}
N 3030 -3890 3160 -3890 {lab=#net3}
N 2810 -3870 2820 -3880 {lab=#net4}
N 2820 -3880 3020 -3880 {lab=#net4}
N 3020 -3880 3030 -3870 {lab=#net4}
N 3030 -3870 3160 -3870 {lab=#net4}
N 3160 -3950 3170 -3960 {lab=rowoff_n[2]}
N 3170 -3960 3370 -3960 {lab=rowoff_n[2]}
N 3370 -3960 3380 -3950 {lab=rowoff_n[2]}
N 3380 -3950 3510 -3950 {lab=rowoff_n[2]}
N 3160 -3930 3170 -3940 {lab=row_n[2]}
N 3170 -3940 3370 -3940 {lab=row_n[2]}
N 3370 -3940 3380 -3930 {lab=row_n[2]}
N 3380 -3930 3510 -3930 {lab=row_n[2]}
N 3160 -3910 3170 -3920 {lab=rowon_n[2]}
N 3170 -3920 3370 -3920 {lab=rowon_n[2]}
N 3370 -3920 3380 -3910 {lab=rowon_n[2]}
N 3380 -3910 3510 -3910 {lab=rowon_n[2]}
N 3370 -3900 3380 -3890 {lab=#net3}
N 3380 -3890 3510 -3890 {lab=#net3}
N 3160 -3870 3170 -3880 {lab=#net4}
N 3170 -3880 3370 -3880 {lab=#net4}
N 3370 -3880 3380 -3870 {lab=#net4}
N 3380 -3870 3510 -3870 {lab=#net4}
N 3160 -3890 3170 -3900 {lab=#net3}
N 3170 -3900 3370 -3900 {lab=#net3}
N 3510 -3950 3520 -3960 {lab=rowoff_n[2]}
N 3520 -3960 3720 -3960 {lab=rowoff_n[2]}
N 3720 -3960 3730 -3950 {lab=rowoff_n[2]}
N 3730 -3950 3850 -3950 {lab=rowoff_n[2]}
N 3510 -3930 3520 -3940 {lab=row_n[2]}
N 3520 -3940 3720 -3940 {lab=row_n[2]}
N 3720 -3940 3730 -3930 {lab=row_n[2]}
N 3730 -3930 3850 -3930 {lab=row_n[2]}
N 3510 -3910 3520 -3920 {lab=rowon_n[2]}
N 3520 -3920 3720 -3920 {lab=rowon_n[2]}
N 3720 -3920 3730 -3910 {lab=rowon_n[2]}
N 3730 -3910 3850 -3910 {lab=rowon_n[2]}
N 3510 -3890 3520 -3900 {lab=#net3}
N 3520 -3900 3720 -3900 {lab=#net3}
N 3720 -3900 3730 -3890 {lab=#net3}
N 3730 -3890 3850 -3890 {lab=#net3}
N 3510 -3870 3520 -3880 {lab=#net4}
N 3520 -3880 3720 -3880 {lab=#net4}
N 3720 -3880 3730 -3870 {lab=#net4}
N 3730 -3870 3850 -3870 {lab=#net4}
N 3850 -3950 3860 -3960 {lab=rowoff_n[2]}
N 3860 -3960 4060 -3960 {lab=rowoff_n[2]}
N 4060 -3960 4070 -3950 {lab=rowoff_n[2]}
N 4070 -3950 4200 -3950 {lab=rowoff_n[2]}
N 3850 -3930 3860 -3940 {lab=row_n[2]}
N 3860 -3940 4060 -3940 {lab=row_n[2]}
N 4060 -3940 4070 -3930 {lab=row_n[2]}
N 4070 -3930 4200 -3930 {lab=row_n[2]}
N 3850 -3910 3860 -3920 {lab=rowon_n[2]}
N 3860 -3920 4060 -3920 {lab=rowon_n[2]}
N 4060 -3920 4070 -3910 {lab=rowon_n[2]}
N 4070 -3910 4200 -3910 {lab=rowon_n[2]}
N 3850 -3890 3860 -3900 {lab=#net3}
N 3860 -3900 4060 -3900 {lab=#net3}
N 3850 -3870 3860 -3880 {lab=#net4}
N 3860 -3880 4060 -3880 {lab=#net4}
N 4060 -3880 4070 -3870 {lab=#net4}
N 4070 -3870 4200 -3870 {lab=#net4}
N 4060 -3900 4070 -3890 {lab=#net3}
N 4070 -3890 4200 -3890 {lab=#net3}
N 4200 -3950 4210 -3960 {lab=rowoff_n[2]}
N 4210 -3960 4410 -3960 {lab=rowoff_n[2]}
N 4410 -3960 4420 -3950 {lab=rowoff_n[2]}
N 4420 -3950 4560 -3950 {lab=rowoff_n[2]}
N 4200 -3930 4210 -3940 {lab=row_n[2]}
N 4210 -3940 4410 -3940 {lab=row_n[2]}
N 4410 -3940 4420 -3930 {lab=row_n[2]}
N 4420 -3930 4560 -3930 {lab=row_n[2]}
N 4200 -3910 4210 -3920 {lab=rowon_n[2]}
N 4210 -3920 4410 -3920 {lab=rowon_n[2]}
N 4410 -3920 4420 -3910 {lab=rowon_n[2]}
N 4420 -3910 4560 -3910 {lab=rowon_n[2]}
N 4200 -3890 4210 -3900 {lab=#net3}
N 4210 -3900 4410 -3900 {lab=#net3}
N 4410 -3900 4420 -3890 {lab=#net3}
N 4420 -3890 4560 -3890 {lab=#net3}
N 4200 -3870 4210 -3880 {lab=#net4}
N 4210 -3880 4410 -3880 {lab=#net4}
N 4410 -3880 4420 -3870 {lab=#net4}
N 4420 -3870 4560 -3870 {lab=#net4}
N 4560 -3950 4570 -3960 {lab=rowoff_n[2]}
N 4570 -3960 4770 -3960 {lab=rowoff_n[2]}
N 4770 -3960 4780 -3950 {lab=rowoff_n[2]}
N 4780 -3950 4890 -3950 {lab=rowoff_n[2]}
N 4560 -3930 4570 -3940 {lab=row_n[2]}
N 4570 -3940 4770 -3940 {lab=row_n[2]}
N 4770 -3940 4780 -3930 {lab=row_n[2]}
N 4780 -3930 4890 -3930 {lab=row_n[2]}
N 4560 -3910 4570 -3920 {lab=rowon_n[2]}
N 4570 -3920 4770 -3920 {lab=rowon_n[2]}
N 4770 -3920 4780 -3910 {lab=rowon_n[2]}
N 4780 -3910 4890 -3910 {lab=rowon_n[2]}
N 4560 -3890 4570 -3900 {lab=#net3}
N 4570 -3900 4770 -3900 {lab=#net3}
N 4770 -3900 4780 -3890 {lab=#net3}
N 4780 -3890 4890 -3890 {lab=#net3}
N 4560 -3870 4570 -3880 {lab=#net4}
N 4570 -3880 4770 -3880 {lab=#net4}
N 4770 -3880 4780 -3870 {lab=#net4}
N 4780 -3870 4890 -3870 {lab=#net4}
N 4890 -3950 4900 -3960 {lab=rowoff_n[2]}
N 4900 -3960 5100 -3960 {lab=rowoff_n[2]}
N 5100 -3960 5110 -3950 {lab=rowoff_n[2]}
N 5110 -3950 5220 -3950 {lab=rowoff_n[2]}
N 4890 -3930 4900 -3940 {lab=row_n[2]}
N 4900 -3940 5100 -3940 {lab=row_n[2]}
N 5100 -3940 5110 -3930 {lab=row_n[2]}
N 5110 -3930 5220 -3930 {lab=row_n[2]}
N 4890 -3910 4900 -3920 {lab=rowon_n[2]}
N 4900 -3920 5100 -3920 {lab=rowon_n[2]}
N 5100 -3920 5110 -3910 {lab=rowon_n[2]}
N 5110 -3910 5220 -3910 {lab=rowon_n[2]}
N 4890 -3890 4900 -3900 {lab=#net3}
N 4900 -3900 5100 -3900 {lab=#net3}
N 5100 -3900 5110 -3890 {lab=#net3}
N 5110 -3890 5220 -3890 {lab=#net3}
N 4890 -3870 4900 -3880 {lab=#net4}
N 4900 -3880 5100 -3880 {lab=#net4}
N 5100 -3880 5120 -3870 {lab=#net4}
N 5120 -3870 5220 -3870 {lab=#net4}
N 5220 -3950 5230 -3960 {lab=rowoff_n[2]}
N 5230 -3960 5430 -3960 {lab=rowoff_n[2]}
N 5430 -3960 5440 -3950 {lab=rowoff_n[2]}
N 5440 -3950 5570 -3950 {lab=rowoff_n[2]}
N 5220 -3930 5230 -3940 {lab=row_n[2]}
N 5230 -3940 5430 -3940 {lab=row_n[2]}
N 5430 -3940 5440 -3930 {lab=row_n[2]}
N 5440 -3930 5570 -3930 {lab=row_n[2]}
N 5220 -3910 5230 -3920 {lab=rowon_n[2]}
N 5230 -3920 5430 -3920 {lab=rowon_n[2]}
N 5430 -3920 5440 -3910 {lab=rowon_n[2]}
N 5440 -3910 5570 -3910 {lab=rowon_n[2]}
N 5220 -3890 5230 -3900 {lab=#net3}
N 5230 -3900 5430 -3900 {lab=#net3}
N 5430 -3900 5440 -3890 {lab=#net3}
N 5440 -3890 5570 -3890 {lab=#net3}
N 5220 -3870 5230 -3880 {lab=#net4}
N 5230 -3880 5430 -3880 {lab=#net4}
N 5430 -3880 5440 -3870 {lab=#net4}
N 5440 -3870 5570 -3870 {lab=#net4}
N 5570 -3950 5580 -3960 {lab=rowoff_n[2]}
N 5580 -3960 5780 -3960 {lab=rowoff_n[2]}
N 5780 -3960 5790 -3950 {lab=rowoff_n[2]}
N 5790 -3950 5920 -3950 {lab=rowoff_n[2]}
N 5570 -3930 5580 -3940 {lab=row_n[2]}
N 5580 -3940 5780 -3940 {lab=row_n[2]}
N 5570 -3910 5580 -3920 {lab=rowon_n[2]}
N 5580 -3920 5780 -3920 {lab=rowon_n[2]}
N 5780 -3920 5790 -3910 {lab=rowon_n[2]}
N 5790 -3910 5920 -3910 {lab=rowon_n[2]}
N 5780 -3940 5790 -3930 {lab=row_n[2]}
N 5790 -3930 5920 -3930 {lab=row_n[2]}
N 5570 -3890 5580 -3900 {lab=#net3}
N 5580 -3900 5780 -3900 {lab=#net3}
N 5780 -3900 5790 -3890 {lab=#net3}
N 5790 -3890 5920 -3890 {lab=#net3}
N 5570 -3870 5580 -3880 {lab=#net4}
N 5580 -3880 5780 -3880 {lab=#net4}
N 5780 -3880 5790 -3870 {lab=#net4}
N 5790 -3870 5920 -3870 {lab=#net4}
N 5920 -3950 5930 -3960 {lab=rowoff_n[2]}
N 5930 -3960 6130 -3960 {lab=rowoff_n[2]}
N 6130 -3960 6140 -3950 {lab=rowoff_n[2]}
N 6140 -3950 6260 -3950 {lab=rowoff_n[2]}
N 5920 -3930 5930 -3940 {lab=row_n[2]}
N 5930 -3940 6130 -3940 {lab=row_n[2]}
N 6130 -3940 6140 -3930 {lab=row_n[2]}
N 6140 -3930 6260 -3930 {lab=row_n[2]}
N 5920 -3910 5930 -3920 {lab=rowon_n[2]}
N 5930 -3920 6130 -3920 {lab=rowon_n[2]}
N 6130 -3920 6140 -3910 {lab=rowon_n[2]}
N 6140 -3910 6260 -3910 {lab=rowon_n[2]}
N 5920 -3890 5930 -3900 {lab=#net3}
N 5930 -3900 6130 -3900 {lab=#net3}
N 6130 -3900 6140 -3890 {lab=#net3}
N 6140 -3890 6260 -3890 {lab=#net3}
N 5920 -3870 5930 -3880 {lab=#net4}
N 5930 -3880 6130 -3880 {lab=#net4}
N 6130 -3880 6140 -3870 {lab=#net4}
N 6140 -3870 6260 -3870 {lab=#net4}
N 6260 -3950 6270 -3960 {lab=rowoff_n[2]}
N 6270 -3960 6470 -3960 {lab=rowoff_n[2]}
N 6470 -3960 6480 -3950 {lab=rowoff_n[2]}
N 6480 -3950 6600 -3950 {lab=rowoff_n[2]}
N 6260 -3930 6270 -3940 {lab=row_n[2]}
N 6270 -3940 6470 -3940 {lab=row_n[2]}
N 6470 -3940 6480 -3930 {lab=row_n[2]}
N 6480 -3930 6600 -3930 {lab=row_n[2]}
N 6260 -3910 6270 -3920 {lab=rowon_n[2]}
N 6270 -3920 6470 -3920 {lab=rowon_n[2]}
N 6470 -3920 6480 -3910 {lab=rowon_n[2]}
N 6480 -3910 6600 -3910 {lab=rowon_n[2]}
N 6260 -3890 6270 -3900 {lab=#net3}
N 6270 -3900 6470 -3900 {lab=#net3}
N 6470 -3900 6480 -3890 {lab=#net3}
N 6480 -3890 6600 -3890 {lab=#net3}
N 6260 -3870 6270 -3880 {lab=#net4}
N 6270 -3880 6470 -3880 {lab=#net4}
N 6470 -3880 6490 -3870 {lab=#net4}
N 6490 -3870 6600 -3870 {lab=#net4}
N 6600 -3950 6610 -3960 {lab=rowoff_n[2]}
N 6610 -3960 6810 -3960 {lab=rowoff_n[2]}
N 6600 -3930 6610 -3940 {lab=row_n[2]}
N 6610 -3940 6810 -3940 {lab=row_n[2]}
N 6810 -3940 6820 -3930 {lab=row_n[2]}
N 6810 -3960 6820 -3950 {lab=rowoff_n[2]}
N 6600 -3910 6610 -3920 {lab=rowon_n[2]}
N 6610 -3920 6810 -3920 {lab=rowon_n[2]}
N 6600 -3890 6610 -3900 {lab=#net3}
N 6610 -3900 6810 -3900 {lab=#net3}
N 6810 -3900 6820 -3890 {lab=#net3}
N 6600 -3870 6610 -3880 {lab=#net4}
N 6610 -3880 6810 -3880 {lab=#net4}
N 6810 -3880 6820 -3870 {lab=#net4}
N 6810 -3920 6820 -3910 {lab=rowon_n[2]}
N 1930 -3460 1940 -3470 {lab=VDD}
N 1940 -3720 1940 -3470 {lab=VDD}
N 1930 -3730 1940 -3720 {lab=VDD}
N 1930 -3790 1930 -3730 {lab=VDD}
N 1950 -3790 1950 -3730 {lab=VSS}
N 1950 -3730 1960 -3720 {lab=VSS}
N 1960 -3720 1960 -3470 {lab=VSS}
N 1950 -3460 1960 -3470 {lab=VSS}
N 2260 -3720 2260 -3470 {lab=col_n[0]}
N 2250 -3730 2260 -3720 {lab=col_n[0]}
N 2250 -3790 2250 -3730 {lab=col_n[0]}
N 2270 -3790 2270 -3730 {lab=col[0]}
N 2270 -3730 2280 -3720 {lab=col[0]}
N 2280 -3720 2280 -3470 {lab=col[0]}
N 2590 -3720 2590 -3470 {lab=col_n[1]}
N 2580 -3730 2590 -3720 {lab=col_n[1]}
N 2580 -3790 2580 -3730 {lab=col_n[1]}
N 2600 -3790 2600 -3730 {lab=col[1]}
N 2600 -3730 2610 -3720 {lab=col[1]}
N 2610 -3720 2610 -3470 {lab=col[1]}
N 2940 -3720 2940 -3470 {lab=col_n[2]}
N 2930 -3730 2940 -3720 {lab=col_n[2]}
N 2930 -3790 2930 -3730 {lab=col_n[2]}
N 2950 -3790 2950 -3730 {lab=col[2]}
N 2950 -3730 2960 -3720 {lab=col[2]}
N 2960 -3720 2960 -3470 {lab=col[2]}
N 3290 -3720 3290 -3470 {lab=col_n[3]}
N 3280 -3730 3290 -3720 {lab=col_n[3]}
N 3280 -3790 3280 -3730 {lab=col_n[3]}
N 3300 -3790 3300 -3730 {lab=col[3]}
N 3300 -3730 3310 -3720 {lab=col[3]}
N 3310 -3720 3310 -3470 {lab=col[3]}
N 3640 -3720 3640 -3470 {lab=col_n[4]}
N 3630 -3730 3640 -3720 {lab=col_n[4]}
N 3630 -3790 3630 -3730 {lab=col_n[4]}
N 3650 -3790 3650 -3730 {lab=col[4]}
N 3650 -3730 3660 -3720 {lab=col[4]}
N 3660 -3720 3660 -3470 {lab=col[4]}
N 3980 -3720 3980 -3470 {lab=col_n[5]}
N 3970 -3730 3980 -3720 {lab=col_n[5]}
N 3970 -3790 3970 -3730 {lab=col_n[5]}
N 3990 -3790 3990 -3730 {lab=col[5]}
N 3990 -3730 4000 -3720 {lab=col[5]}
N 4000 -3720 4000 -3470 {lab=col[5]}
N 4330 -3720 4330 -3470 {lab=col_n[6]}
N 4320 -3730 4330 -3720 {lab=col_n[6]}
N 4320 -3790 4320 -3730 {lab=col_n[6]}
N 4340 -3790 4340 -3730 {lab=col[6]}
N 4340 -3730 4350 -3720 {lab=col[6]}
N 4350 -3720 4350 -3470 {lab=col[6]}
N 4690 -3720 4690 -3470 {lab=col_n[7]}
N 4680 -3730 4690 -3720 {lab=col_n[7]}
N 4680 -3790 4680 -3730 {lab=col_n[7]}
N 4700 -3790 4700 -3730 {lab=col[7]}
N 4700 -3730 4710 -3720 {lab=col[7]}
N 4710 -3720 4710 -3470 {lab=col[7]}
N 5020 -3720 5020 -3470 {lab=col_n[8]}
N 5010 -3730 5020 -3720 {lab=col_n[8]}
N 5010 -3790 5010 -3730 {lab=col_n[8]}
N 5030 -3790 5030 -3730 {lab=col[8]}
N 5030 -3730 5040 -3720 {lab=col[8]}
N 5040 -3720 5040 -3470 {lab=col[8]}
N 5350 -3720 5350 -3470 {lab=col_n[9]}
N 5340 -3730 5350 -3720 {lab=col_n[9]}
N 5340 -3790 5340 -3730 {lab=col_n[9]}
N 5360 -3790 5360 -3730 {lab=col[9]}
N 5360 -3730 5370 -3720 {lab=col[9]}
N 5370 -3720 5370 -3470 {lab=col[9]}
N 5700 -3720 5700 -3470 {lab=col_n[10]}
N 5690 -3730 5700 -3720 {lab=col_n[10]}
N 5690 -3790 5690 -3730 {lab=col_n[10]}
N 5710 -3790 5710 -3730 {lab=col[10]}
N 5710 -3730 5720 -3720 {lab=col[10]}
N 5720 -3720 5720 -3470 {lab=col[10]}
N 6050 -3720 6050 -3470 {lab=col_n[11]}
N 6040 -3730 6050 -3720 {lab=col_n[11]}
N 6040 -3790 6040 -3730 {lab=col_n[11]}
N 6060 -3790 6060 -3730 {lab=col[11]}
N 6060 -3730 6070 -3720 {lab=col[11]}
N 6070 -3720 6070 -3470 {lab=col[11]}
N 6390 -3720 6390 -3470 {lab=col_n[12]}
N 6380 -3730 6390 -3720 {lab=col_n[12]}
N 6380 -3790 6380 -3730 {lab=col_n[12]}
N 6400 -3790 6400 -3730 {lab=col[12]}
N 6400 -3730 6410 -3720 {lab=col[12]}
N 6410 -3720 6410 -3470 {lab=col[12]}
N 6730 -3720 6730 -3470 {lab=VDD}
N 6720 -3730 6730 -3720 {lab=VDD}
N 6720 -3790 6720 -3730 {lab=VDD}
N 6740 -3790 6740 -3730 {lab=VSS}
N 6740 -3730 6750 -3720 {lab=VSS}
N 6750 -3720 6750 -3470 {lab=VSS}
N 6740 -3460 6750 -3470 {lab=VSS}
N 6720 -3460 6730 -3470 {lab=VDD}
N 6380 -3460 6390 -3470 {lab=col_n[12]}
N 6400 -3460 6410 -3470 {lab=col[12]}
N 6040 -3460 6050 -3470 {lab=col_n[11]}
N 6060 -3460 6070 -3470 {lab=col[11]}
N 5690 -3460 5700 -3470 {lab=col_n[10]}
N 5710 -3460 5720 -3470 {lab=col[10]}
N 5360 -3460 5370 -3470 {lab=col[9]}
N 5340 -3460 5350 -3470 {lab=col_n[9]}
N 5030 -3460 5040 -3470 {lab=col[8]}
N 5010 -3460 5020 -3470 {lab=col_n[8]}
N 4680 -3460 4690 -3470 {lab=col_n[7]}
N 4700 -3460 4710 -3470 {lab=col[7]}
N 4320 -3460 4330 -3470 {lab=col_n[6]}
N 4340 -3460 4350 -3470 {lab=col[6]}
N 3990 -3460 4000 -3470 {lab=col[5]}
N 3970 -3460 3980 -3470 {lab=col_n[5]}
N 3650 -3460 3660 -3470 {lab=col[4]}
N 3630 -3460 3640 -3470 {lab=col_n[4]}
N 3300 -3460 3310 -3470 {lab=col[3]}
N 3280 -3460 3290 -3470 {lab=col_n[3]}
N 2950 -3460 2960 -3470 {lab=col[2]}
N 2930 -3460 2940 -3470 {lab=col_n[2]}
N 2600 -3460 2610 -3470 {lab=col[1]}
N 2580 -3460 2590 -3470 {lab=col_n[1]}
N 2250 -3460 2260 -3470 {lab=col_n[0]}
N 2270 -3460 2280 -3470 {lab=col[0]}
N 1930 -3420 1940 -3410 {lab=VDD}
N 1930 -3460 1930 -3420 {lab=VDD}
N 1950 -3460 1950 -3420 {lab=VSS}
N 1950 -3420 1960 -3410 {lab=VSS}
N 1850 -4110 1850 -4100 {
lab=VSS}
N 2170 -4110 2170 -4100 {
lab=VSS}
N 2500 -4110 2500 -4100 {
lab=VSS}
N 2850 -4110 2850 -4100 {
lab=VSS}
N 3200 -4110 3200 -4100 {
lab=VSS}
N 3550 -4110 3550 -4100 {
lab=VSS}
N 3890 -4110 3890 -4100 {
lab=VSS}
N 4240 -4110 4240 -4100 {
lab=VSS}
N 4600 -4110 4600 -4100 {
lab=VSS}
N 4930 -4110 4930 -4100 {
lab=VSS}
N 5260 -4110 5260 -4100 {
lab=VSS}
N 5610 -4110 5610 -4100 {
lab=VSS}
N 5960 -4110 5960 -4100 {
lab=VSS}
N 6300 -4110 6300 -4100 {
lab=VSS}
N 6640 -4110 6640 -4100 {
lab=VSS}
N 6660 -4350 6660 -4330 {
lab=vcm}
N 6640 -4340 6640 -4330 {
lab=VDD}
N 6700 -4350 6700 -4330 {
lab=ctop}
N 5980 -4350 5980 -4330 {
lab=vcm}
N 5960 -4340 5960 -4330 {
lab=VDD}
N 6020 -4350 6020 -4330 {
lab=ctop}
N 6320 -4350 6320 -4330 {
lab=vcm}
N 6300 -4340 6300 -4330 {
lab=VDD}
N 6360 -4350 6360 -4330 {
lab=ctop}
N 5630 -4350 5630 -4330 {
lab=vcm}
N 5610 -4340 5610 -4330 {
lab=VDD}
N 5670 -4350 5670 -4330 {
lab=ctop}
N 5280 -4350 5280 -4330 {
lab=vcm}
N 5260 -4340 5260 -4330 {
lab=VDD}
N 5320 -4350 5320 -4330 {
lab=ctop}
N 4950 -4350 4950 -4330 {
lab=vcm}
N 4930 -4340 4930 -4330 {
lab=VDD}
N 4990 -4350 4990 -4330 {
lab=ctop}
N 4620 -4350 4620 -4330 {
lab=vcm}
N 4600 -4340 4600 -4330 {
lab=VDD}
N 4660 -4350 4660 -4330 {
lab=ctop}
N 4260 -4350 4260 -4330 {
lab=vcm}
N 4240 -4340 4240 -4330 {
lab=VDD}
N 4300 -4350 4300 -4330 {
lab=ctop}
N 3910 -4350 3910 -4330 {
lab=vcm}
N 3890 -4340 3890 -4330 {
lab=VDD}
N 3950 -4350 3950 -4330 {
lab=ctop}
N 3570 -4350 3570 -4330 {
lab=vcm}
N 3550 -4340 3550 -4330 {
lab=VDD}
N 3610 -4350 3610 -4330 {
lab=ctop}
N 3220 -4350 3220 -4330 {
lab=vcm}
N 3200 -4340 3200 -4330 {
lab=VDD}
N 3260 -4350 3260 -4330 {
lab=ctop}
N 2870 -4350 2870 -4330 {
lab=vcm}
N 2850 -4340 2850 -4330 {
lab=VDD}
N 2910 -4350 2910 -4330 {
lab=ctop}
N 2520 -4350 2520 -4330 {
lab=vcm}
N 2500 -4340 2500 -4330 {
lab=VDD}
N 2560 -4350 2560 -4330 {
lab=ctop}
N 2190 -4350 2190 -4330 {
lab=vcm}
N 2170 -4340 2170 -4330 {
lab=VDD}
N 2230 -4350 2230 -4330 {
lab=ctop}
N 1870 -4350 1870 -4330 {
lab=vcm}
N 1850 -4340 1850 -4330 {
lab=VDD}
N 1910 -4350 1910 -4330 {
lab=ctop}
N 1790 -4190 1810 -4190 {
lab=sample_n}
N 1790 -4210 1810 -4210 {
lab=sample}
N 1790 -4230 1810 -4230 {
lab=rowon_n[3]}
N 1790 -4250 1810 -4250 {
lab=row_n[3]}
N 1790 -4270 1810 -4270 {
lab=rowoff_n[3]}
N 2030 -4210 2130 -4210 {lab=#net5}
N 2030 -4190 2130 -4190 {lab=#net6}
N 1810 -4270 1820 -4280 {lab=rowoff_n[3]}
N 1820 -4280 2040 -4280 {lab=rowoff_n[3]}
N 2040 -4280 2050 -4270 {lab=rowoff_n[3]}
N 2050 -4270 2130 -4270 {lab=rowoff_n[3]}
N 1810 -4250 1820 -4260 {lab=row_n[3]}
N 1820 -4260 2040 -4260 {lab=row_n[3]}
N 2040 -4260 2050 -4250 {lab=row_n[3]}
N 2050 -4250 2130 -4250 {lab=row_n[3]}
N 1810 -4230 1820 -4240 {lab=rowon_n[3]}
N 1820 -4240 2040 -4240 {lab=rowon_n[3]}
N 2040 -4240 2050 -4230 {lab=rowon_n[3]}
N 2050 -4230 2130 -4230 {lab=rowon_n[3]}
N 2130 -4270 2140 -4280 {lab=rowoff_n[3]}
N 2130 -4250 2140 -4260 {lab=row_n[3]}
N 2140 -4260 2340 -4260 {lab=row_n[3]}
N 2340 -4260 2350 -4250 {lab=row_n[3]}
N 2350 -4250 2460 -4250 {lab=row_n[3]}
N 2140 -4280 2340 -4280 {lab=rowoff_n[3]}
N 2340 -4280 2350 -4270 {lab=rowoff_n[3]}
N 2350 -4270 2460 -4270 {lab=rowoff_n[3]}
N 2130 -4230 2140 -4240 {lab=rowon_n[3]}
N 2140 -4240 2340 -4240 {lab=rowon_n[3]}
N 2340 -4240 2350 -4230 {lab=rowon_n[3]}
N 2350 -4230 2460 -4230 {lab=rowon_n[3]}
N 2130 -4210 2140 -4220 {lab=#net5}
N 2140 -4220 2340 -4220 {lab=#net5}
N 2340 -4220 2350 -4210 {lab=#net5}
N 2350 -4210 2460 -4210 {lab=#net5}
N 2130 -4190 2140 -4200 {lab=#net6}
N 2140 -4200 2340 -4200 {lab=#net6}
N 2340 -4200 2350 -4190 {lab=#net6}
N 2350 -4190 2460 -4190 {lab=#net6}
N 2460 -4250 2470 -4260 {lab=row_n[3]}
N 2470 -4260 2670 -4260 {lab=row_n[3]}
N 2670 -4260 2680 -4250 {lab=row_n[3]}
N 2680 -4250 2810 -4250 {lab=row_n[3]}
N 2460 -4230 2470 -4240 {lab=rowon_n[3]}
N 2470 -4240 2670 -4240 {lab=rowon_n[3]}
N 2670 -4240 2680 -4230 {lab=rowon_n[3]}
N 2680 -4230 2810 -4230 {lab=rowon_n[3]}
N 2460 -4210 2470 -4220 {lab=#net5}
N 2470 -4220 2670 -4220 {lab=#net5}
N 2670 -4220 2680 -4210 {lab=#net5}
N 2680 -4210 2810 -4210 {lab=#net5}
N 2460 -4190 2480 -4200 {lab=#net6}
N 2480 -4200 2670 -4200 {lab=#net6}
N 2670 -4200 2680 -4190 {lab=#net6}
N 2680 -4190 2810 -4190 {lab=#net6}
N 2460 -4270 2470 -4280 {lab=rowoff_n[3]}
N 2470 -4280 2670 -4280 {lab=rowoff_n[3]}
N 2670 -4280 2680 -4270 {lab=rowoff_n[3]}
N 2680 -4270 2810 -4270 {lab=rowoff_n[3]}
N 2810 -4270 2820 -4280 {lab=rowoff_n[3]}
N 2820 -4280 3020 -4280 {lab=rowoff_n[3]}
N 3020 -4280 3030 -4270 {lab=rowoff_n[3]}
N 3030 -4270 3160 -4270 {lab=rowoff_n[3]}
N 2810 -4250 2820 -4260 {lab=row_n[3]}
N 2820 -4260 3020 -4260 {lab=row_n[3]}
N 3020 -4260 3030 -4250 {lab=row_n[3]}
N 3030 -4250 3160 -4250 {lab=row_n[3]}
N 2810 -4230 2820 -4240 {lab=rowon_n[3]}
N 2820 -4240 3020 -4240 {lab=rowon_n[3]}
N 3020 -4240 3030 -4230 {lab=rowon_n[3]}
N 3030 -4230 3160 -4230 {lab=rowon_n[3]}
N 2810 -4210 2820 -4220 {lab=#net5}
N 2820 -4220 3020 -4220 {lab=#net5}
N 3020 -4220 3030 -4210 {lab=#net5}
N 3030 -4210 3160 -4210 {lab=#net5}
N 2810 -4190 2820 -4200 {lab=#net6}
N 2820 -4200 3020 -4200 {lab=#net6}
N 3020 -4200 3030 -4190 {lab=#net6}
N 3030 -4190 3160 -4190 {lab=#net6}
N 3160 -4270 3170 -4280 {lab=rowoff_n[3]}
N 3170 -4280 3370 -4280 {lab=rowoff_n[3]}
N 3370 -4280 3380 -4270 {lab=rowoff_n[3]}
N 3380 -4270 3510 -4270 {lab=rowoff_n[3]}
N 3160 -4250 3170 -4260 {lab=row_n[3]}
N 3170 -4260 3370 -4260 {lab=row_n[3]}
N 3370 -4260 3380 -4250 {lab=row_n[3]}
N 3380 -4250 3510 -4250 {lab=row_n[3]}
N 3160 -4230 3170 -4240 {lab=rowon_n[3]}
N 3170 -4240 3370 -4240 {lab=rowon_n[3]}
N 3370 -4240 3380 -4230 {lab=rowon_n[3]}
N 3380 -4230 3510 -4230 {lab=rowon_n[3]}
N 3370 -4220 3380 -4210 {lab=#net5}
N 3380 -4210 3510 -4210 {lab=#net5}
N 3160 -4190 3170 -4200 {lab=#net6}
N 3170 -4200 3370 -4200 {lab=#net6}
N 3370 -4200 3380 -4190 {lab=#net6}
N 3380 -4190 3510 -4190 {lab=#net6}
N 3160 -4210 3170 -4220 {lab=#net5}
N 3170 -4220 3370 -4220 {lab=#net5}
N 3510 -4270 3520 -4280 {lab=rowoff_n[3]}
N 3520 -4280 3720 -4280 {lab=rowoff_n[3]}
N 3720 -4280 3730 -4270 {lab=rowoff_n[3]}
N 3730 -4270 3850 -4270 {lab=rowoff_n[3]}
N 3510 -4250 3520 -4260 {lab=row_n[3]}
N 3520 -4260 3720 -4260 {lab=row_n[3]}
N 3720 -4260 3730 -4250 {lab=row_n[3]}
N 3730 -4250 3850 -4250 {lab=row_n[3]}
N 3510 -4230 3520 -4240 {lab=rowon_n[3]}
N 3520 -4240 3720 -4240 {lab=rowon_n[3]}
N 3720 -4240 3730 -4230 {lab=rowon_n[3]}
N 3730 -4230 3850 -4230 {lab=rowon_n[3]}
N 3510 -4210 3520 -4220 {lab=#net5}
N 3520 -4220 3720 -4220 {lab=#net5}
N 3720 -4220 3730 -4210 {lab=#net5}
N 3730 -4210 3850 -4210 {lab=#net5}
N 3510 -4190 3520 -4200 {lab=#net6}
N 3520 -4200 3720 -4200 {lab=#net6}
N 3720 -4200 3730 -4190 {lab=#net6}
N 3730 -4190 3850 -4190 {lab=#net6}
N 3850 -4270 3860 -4280 {lab=rowoff_n[3]}
N 3860 -4280 4060 -4280 {lab=rowoff_n[3]}
N 4060 -4280 4070 -4270 {lab=rowoff_n[3]}
N 4070 -4270 4200 -4270 {lab=rowoff_n[3]}
N 3850 -4250 3860 -4260 {lab=row_n[3]}
N 3860 -4260 4060 -4260 {lab=row_n[3]}
N 4060 -4260 4070 -4250 {lab=row_n[3]}
N 4070 -4250 4200 -4250 {lab=row_n[3]}
N 3850 -4230 3860 -4240 {lab=rowon_n[3]}
N 3860 -4240 4060 -4240 {lab=rowon_n[3]}
N 4060 -4240 4070 -4230 {lab=rowon_n[3]}
N 4070 -4230 4200 -4230 {lab=rowon_n[3]}
N 3850 -4210 3860 -4220 {lab=#net5}
N 3860 -4220 4060 -4220 {lab=#net5}
N 3850 -4190 3860 -4200 {lab=#net6}
N 3860 -4200 4060 -4200 {lab=#net6}
N 4060 -4200 4070 -4190 {lab=#net6}
N 4070 -4190 4200 -4190 {lab=#net6}
N 4060 -4220 4070 -4210 {lab=#net5}
N 4070 -4210 4200 -4210 {lab=#net5}
N 4200 -4270 4210 -4280 {lab=rowoff_n[3]}
N 4210 -4280 4410 -4280 {lab=rowoff_n[3]}
N 4410 -4280 4420 -4270 {lab=rowoff_n[3]}
N 4420 -4270 4560 -4270 {lab=rowoff_n[3]}
N 4200 -4250 4210 -4260 {lab=row_n[3]}
N 4210 -4260 4410 -4260 {lab=row_n[3]}
N 4410 -4260 4420 -4250 {lab=row_n[3]}
N 4420 -4250 4560 -4250 {lab=row_n[3]}
N 4200 -4230 4210 -4240 {lab=rowon_n[3]}
N 4210 -4240 4410 -4240 {lab=rowon_n[3]}
N 4410 -4240 4420 -4230 {lab=rowon_n[3]}
N 4420 -4230 4560 -4230 {lab=rowon_n[3]}
N 4200 -4210 4210 -4220 {lab=#net5}
N 4210 -4220 4410 -4220 {lab=#net5}
N 4410 -4220 4420 -4210 {lab=#net5}
N 4420 -4210 4560 -4210 {lab=#net5}
N 4200 -4190 4210 -4200 {lab=#net6}
N 4210 -4200 4410 -4200 {lab=#net6}
N 4410 -4200 4420 -4190 {lab=#net6}
N 4420 -4190 4560 -4190 {lab=#net6}
N 4560 -4270 4570 -4280 {lab=rowoff_n[3]}
N 4570 -4280 4770 -4280 {lab=rowoff_n[3]}
N 4770 -4280 4780 -4270 {lab=rowoff_n[3]}
N 4780 -4270 4890 -4270 {lab=rowoff_n[3]}
N 4560 -4250 4570 -4260 {lab=row_n[3]}
N 4570 -4260 4770 -4260 {lab=row_n[3]}
N 4770 -4260 4780 -4250 {lab=row_n[3]}
N 4780 -4250 4890 -4250 {lab=row_n[3]}
N 4560 -4230 4570 -4240 {lab=rowon_n[3]}
N 4570 -4240 4770 -4240 {lab=rowon_n[3]}
N 4770 -4240 4780 -4230 {lab=rowon_n[3]}
N 4780 -4230 4890 -4230 {lab=rowon_n[3]}
N 4560 -4210 4570 -4220 {lab=#net5}
N 4570 -4220 4770 -4220 {lab=#net5}
N 4770 -4220 4780 -4210 {lab=#net5}
N 4780 -4210 4890 -4210 {lab=#net5}
N 4560 -4190 4570 -4200 {lab=#net6}
N 4570 -4200 4770 -4200 {lab=#net6}
N 4770 -4200 4780 -4190 {lab=#net6}
N 4780 -4190 4890 -4190 {lab=#net6}
N 4890 -4270 4900 -4280 {lab=rowoff_n[3]}
N 4900 -4280 5100 -4280 {lab=rowoff_n[3]}
N 5100 -4280 5110 -4270 {lab=rowoff_n[3]}
N 5110 -4270 5220 -4270 {lab=rowoff_n[3]}
N 4890 -4250 4900 -4260 {lab=row_n[3]}
N 4900 -4260 5100 -4260 {lab=row_n[3]}
N 5100 -4260 5110 -4250 {lab=row_n[3]}
N 5110 -4250 5220 -4250 {lab=row_n[3]}
N 4890 -4230 4900 -4240 {lab=rowon_n[3]}
N 4900 -4240 5100 -4240 {lab=rowon_n[3]}
N 5100 -4240 5110 -4230 {lab=rowon_n[3]}
N 5110 -4230 5220 -4230 {lab=rowon_n[3]}
N 4890 -4210 4900 -4220 {lab=#net5}
N 4900 -4220 5100 -4220 {lab=#net5}
N 5100 -4220 5110 -4210 {lab=#net5}
N 5110 -4210 5220 -4210 {lab=#net5}
N 4890 -4190 4900 -4200 {lab=#net6}
N 4900 -4200 5100 -4200 {lab=#net6}
N 5100 -4200 5120 -4190 {lab=#net6}
N 5120 -4190 5220 -4190 {lab=#net6}
N 5220 -4270 5230 -4280 {lab=rowoff_n[3]}
N 5230 -4280 5430 -4280 {lab=rowoff_n[3]}
N 5430 -4280 5440 -4270 {lab=rowoff_n[3]}
N 5440 -4270 5570 -4270 {lab=rowoff_n[3]}
N 5220 -4250 5230 -4260 {lab=row_n[3]}
N 5230 -4260 5430 -4260 {lab=row_n[3]}
N 5430 -4260 5440 -4250 {lab=row_n[3]}
N 5440 -4250 5570 -4250 {lab=row_n[3]}
N 5220 -4230 5230 -4240 {lab=rowon_n[3]}
N 5230 -4240 5430 -4240 {lab=rowon_n[3]}
N 5430 -4240 5440 -4230 {lab=rowon_n[3]}
N 5440 -4230 5570 -4230 {lab=rowon_n[3]}
N 5220 -4210 5230 -4220 {lab=#net5}
N 5230 -4220 5430 -4220 {lab=#net5}
N 5430 -4220 5440 -4210 {lab=#net5}
N 5440 -4210 5570 -4210 {lab=#net5}
N 5220 -4190 5230 -4200 {lab=#net6}
N 5230 -4200 5430 -4200 {lab=#net6}
N 5430 -4200 5440 -4190 {lab=#net6}
N 5440 -4190 5570 -4190 {lab=#net6}
N 5570 -4270 5580 -4280 {lab=rowoff_n[3]}
N 5580 -4280 5780 -4280 {lab=rowoff_n[3]}
N 5780 -4280 5790 -4270 {lab=rowoff_n[3]}
N 5790 -4270 5920 -4270 {lab=rowoff_n[3]}
N 5570 -4250 5580 -4260 {lab=row_n[3]}
N 5580 -4260 5780 -4260 {lab=row_n[3]}
N 5570 -4230 5580 -4240 {lab=rowon_n[3]}
N 5580 -4240 5780 -4240 {lab=rowon_n[3]}
N 5780 -4240 5790 -4230 {lab=rowon_n[3]}
N 5790 -4230 5920 -4230 {lab=rowon_n[3]}
N 5780 -4260 5790 -4250 {lab=row_n[3]}
N 5790 -4250 5920 -4250 {lab=row_n[3]}
N 5570 -4210 5580 -4220 {lab=#net5}
N 5580 -4220 5780 -4220 {lab=#net5}
N 5780 -4220 5790 -4210 {lab=#net5}
N 5790 -4210 5920 -4210 {lab=#net5}
N 5570 -4190 5580 -4200 {lab=#net6}
N 5580 -4200 5780 -4200 {lab=#net6}
N 5780 -4200 5790 -4190 {lab=#net6}
N 5790 -4190 5920 -4190 {lab=#net6}
N 5920 -4270 5930 -4280 {lab=rowoff_n[3]}
N 5930 -4280 6130 -4280 {lab=rowoff_n[3]}
N 6130 -4280 6140 -4270 {lab=rowoff_n[3]}
N 6140 -4270 6260 -4270 {lab=rowoff_n[3]}
N 5920 -4250 5930 -4260 {lab=row_n[3]}
N 5930 -4260 6130 -4260 {lab=row_n[3]}
N 6130 -4260 6140 -4250 {lab=row_n[3]}
N 6140 -4250 6260 -4250 {lab=row_n[3]}
N 5920 -4230 5930 -4240 {lab=rowon_n[3]}
N 5930 -4240 6130 -4240 {lab=rowon_n[3]}
N 6130 -4240 6140 -4230 {lab=rowon_n[3]}
N 6140 -4230 6260 -4230 {lab=rowon_n[3]}
N 5920 -4210 5930 -4220 {lab=#net5}
N 5930 -4220 6130 -4220 {lab=#net5}
N 6130 -4220 6140 -4210 {lab=#net5}
N 6140 -4210 6260 -4210 {lab=#net5}
N 5920 -4190 5930 -4200 {lab=#net6}
N 5930 -4200 6130 -4200 {lab=#net6}
N 6130 -4200 6140 -4190 {lab=#net6}
N 6140 -4190 6260 -4190 {lab=#net6}
N 6260 -4270 6270 -4280 {lab=rowoff_n[3]}
N 6270 -4280 6470 -4280 {lab=rowoff_n[3]}
N 6470 -4280 6480 -4270 {lab=rowoff_n[3]}
N 6480 -4270 6600 -4270 {lab=rowoff_n[3]}
N 6260 -4250 6270 -4260 {lab=row_n[3]}
N 6270 -4260 6470 -4260 {lab=row_n[3]}
N 6470 -4260 6480 -4250 {lab=row_n[3]}
N 6480 -4250 6600 -4250 {lab=row_n[3]}
N 6260 -4230 6270 -4240 {lab=rowon_n[3]}
N 6270 -4240 6470 -4240 {lab=rowon_n[3]}
N 6470 -4240 6480 -4230 {lab=rowon_n[3]}
N 6480 -4230 6600 -4230 {lab=rowon_n[3]}
N 6260 -4210 6270 -4220 {lab=#net5}
N 6270 -4220 6470 -4220 {lab=#net5}
N 6470 -4220 6480 -4210 {lab=#net5}
N 6480 -4210 6600 -4210 {lab=#net5}
N 6260 -4190 6270 -4200 {lab=#net6}
N 6270 -4200 6470 -4200 {lab=#net6}
N 6470 -4200 6490 -4190 {lab=#net6}
N 6490 -4190 6600 -4190 {lab=#net6}
N 6600 -4270 6610 -4280 {lab=rowoff_n[3]}
N 6610 -4280 6810 -4280 {lab=rowoff_n[3]}
N 6600 -4250 6610 -4260 {lab=row_n[3]}
N 6610 -4260 6810 -4260 {lab=row_n[3]}
N 6810 -4260 6820 -4250 {lab=row_n[3]}
N 6810 -4280 6820 -4270 {lab=rowoff_n[3]}
N 6600 -4230 6610 -4240 {lab=rowon_n[3]}
N 6610 -4240 6810 -4240 {lab=rowon_n[3]}
N 6600 -4210 6610 -4220 {lab=#net5}
N 6610 -4220 6810 -4220 {lab=#net5}
N 6810 -4220 6820 -4210 {lab=#net5}
N 6600 -4190 6610 -4200 {lab=#net6}
N 6610 -4200 6810 -4200 {lab=#net6}
N 6810 -4200 6820 -4190 {lab=#net6}
N 6810 -4240 6820 -4230 {lab=rowon_n[3]}
N 1850 -4440 1850 -4430 {
lab=VSS}
N 2170 -4440 2170 -4430 {
lab=VSS}
N 2500 -4440 2500 -4430 {
lab=VSS}
N 2850 -4440 2850 -4430 {
lab=VSS}
N 3200 -4440 3200 -4430 {
lab=VSS}
N 3550 -4440 3550 -4430 {
lab=VSS}
N 3890 -4440 3890 -4430 {
lab=VSS}
N 4240 -4440 4240 -4430 {
lab=VSS}
N 4600 -4440 4600 -4430 {
lab=VSS}
N 4930 -4440 4930 -4430 {
lab=VSS}
N 5260 -4440 5260 -4430 {
lab=VSS}
N 5610 -4440 5610 -4430 {
lab=VSS}
N 5960 -4440 5960 -4430 {
lab=VSS}
N 6300 -4440 6300 -4430 {
lab=VSS}
N 6640 -4440 6640 -4430 {
lab=VSS}
N 6660 -4680 6660 -4660 {
lab=vcm}
N 6640 -4670 6640 -4660 {
lab=VDD}
N 6700 -4680 6700 -4660 {
lab=ctop}
N 5980 -4680 5980 -4660 {
lab=vcm}
N 5960 -4670 5960 -4660 {
lab=VDD}
N 6020 -4680 6020 -4660 {
lab=ctop}
N 6320 -4680 6320 -4660 {
lab=vcm}
N 6300 -4670 6300 -4660 {
lab=VDD}
N 6360 -4680 6360 -4660 {
lab=ctop}
N 5630 -4680 5630 -4660 {
lab=vcm}
N 5610 -4670 5610 -4660 {
lab=VDD}
N 5670 -4680 5670 -4660 {
lab=ctop}
N 5280 -4680 5280 -4660 {
lab=vcm}
N 5260 -4670 5260 -4660 {
lab=VDD}
N 5320 -4680 5320 -4660 {
lab=ctop}
N 4950 -4680 4950 -4660 {
lab=vcm}
N 4930 -4670 4930 -4660 {
lab=VDD}
N 4990 -4680 4990 -4660 {
lab=ctop}
N 4620 -4680 4620 -4660 {
lab=vcm}
N 4600 -4670 4600 -4660 {
lab=VDD}
N 4660 -4680 4660 -4660 {
lab=ctop}
N 4260 -4680 4260 -4660 {
lab=vcm}
N 4240 -4670 4240 -4660 {
lab=VDD}
N 4300 -4680 4300 -4660 {
lab=ctop}
N 3910 -4680 3910 -4660 {
lab=vcm}
N 3890 -4670 3890 -4660 {
lab=VDD}
N 3950 -4680 3950 -4660 {
lab=ctop}
N 3570 -4680 3570 -4660 {
lab=vcm}
N 3550 -4670 3550 -4660 {
lab=VDD}
N 3610 -4680 3610 -4660 {
lab=ctop}
N 3220 -4680 3220 -4660 {
lab=vcm}
N 3200 -4670 3200 -4660 {
lab=VDD}
N 3260 -4680 3260 -4660 {
lab=ctop}
N 2870 -4680 2870 -4660 {
lab=vcm}
N 2850 -4670 2850 -4660 {
lab=VDD}
N 2910 -4680 2910 -4660 {
lab=ctop}
N 2520 -4680 2520 -4660 {
lab=vcm}
N 2500 -4670 2500 -4660 {
lab=VDD}
N 2560 -4680 2560 -4660 {
lab=ctop}
N 2190 -4680 2190 -4660 {
lab=vcm}
N 2170 -4670 2170 -4660 {
lab=VDD}
N 2230 -4680 2230 -4660 {
lab=ctop}
N 1870 -4680 1870 -4660 {
lab=vcm}
N 1850 -4670 1850 -4660 {
lab=VDD}
N 1910 -4680 1910 -4660 {
lab=ctop}
N 1790 -4520 1810 -4520 {
lab=sample_n}
N 1790 -4540 1810 -4540 {
lab=sample}
N 1790 -4560 1810 -4560 {
lab=rowon_n[4]}
N 1790 -4580 1810 -4580 {
lab=row_n[4]}
N 1790 -4600 1810 -4600 {
lab=rowoff_n[4]}
N 2030 -4540 2130 -4540 {lab=#net7}
N 2030 -4520 2130 -4520 {lab=#net8}
N 1810 -4600 1820 -4610 {lab=rowoff_n[4]}
N 1820 -4610 2040 -4610 {lab=rowoff_n[4]}
N 2040 -4610 2050 -4600 {lab=rowoff_n[4]}
N 2050 -4600 2130 -4600 {lab=rowoff_n[4]}
N 1810 -4580 1820 -4590 {lab=row_n[4]}
N 1820 -4590 2040 -4590 {lab=row_n[4]}
N 2040 -4590 2050 -4580 {lab=row_n[4]}
N 2050 -4580 2130 -4580 {lab=row_n[4]}
N 1810 -4560 1820 -4570 {lab=rowon_n[4]}
N 1820 -4570 2040 -4570 {lab=rowon_n[4]}
N 2040 -4570 2050 -4560 {lab=rowon_n[4]}
N 2050 -4560 2130 -4560 {lab=rowon_n[4]}
N 2130 -4600 2140 -4610 {lab=rowoff_n[4]}
N 2130 -4580 2140 -4590 {lab=row_n[4]}
N 2140 -4590 2340 -4590 {lab=row_n[4]}
N 2340 -4590 2350 -4580 {lab=row_n[4]}
N 2350 -4580 2460 -4580 {lab=row_n[4]}
N 2140 -4610 2340 -4610 {lab=rowoff_n[4]}
N 2340 -4610 2350 -4600 {lab=rowoff_n[4]}
N 2350 -4600 2460 -4600 {lab=rowoff_n[4]}
N 2130 -4560 2140 -4570 {lab=rowon_n[4]}
N 2140 -4570 2340 -4570 {lab=rowon_n[4]}
N 2340 -4570 2350 -4560 {lab=rowon_n[4]}
N 2350 -4560 2460 -4560 {lab=rowon_n[4]}
N 2130 -4540 2140 -4550 {lab=#net7}
N 2140 -4550 2340 -4550 {lab=#net7}
N 2340 -4550 2350 -4540 {lab=#net7}
N 2350 -4540 2460 -4540 {lab=#net7}
N 2130 -4520 2140 -4530 {lab=#net8}
N 2140 -4530 2340 -4530 {lab=#net8}
N 2340 -4530 2350 -4520 {lab=#net8}
N 2350 -4520 2460 -4520 {lab=#net8}
N 2460 -4580 2470 -4590 {lab=row_n[4]}
N 2470 -4590 2670 -4590 {lab=row_n[4]}
N 2670 -4590 2680 -4580 {lab=row_n[4]}
N 2680 -4580 2810 -4580 {lab=row_n[4]}
N 2460 -4560 2470 -4570 {lab=rowon_n[4]}
N 2470 -4570 2670 -4570 {lab=rowon_n[4]}
N 2670 -4570 2680 -4560 {lab=rowon_n[4]}
N 2680 -4560 2810 -4560 {lab=rowon_n[4]}
N 2460 -4540 2470 -4550 {lab=#net7}
N 2470 -4550 2670 -4550 {lab=#net7}
N 2670 -4550 2680 -4540 {lab=#net7}
N 2680 -4540 2810 -4540 {lab=#net7}
N 2460 -4520 2480 -4530 {lab=#net8}
N 2480 -4530 2670 -4530 {lab=#net8}
N 2670 -4530 2680 -4520 {lab=#net8}
N 2680 -4520 2810 -4520 {lab=#net8}
N 2460 -4600 2470 -4610 {lab=rowoff_n[4]}
N 2470 -4610 2670 -4610 {lab=rowoff_n[4]}
N 2670 -4610 2680 -4600 {lab=rowoff_n[4]}
N 2680 -4600 2810 -4600 {lab=rowoff_n[4]}
N 2810 -4600 2820 -4610 {lab=rowoff_n[4]}
N 2820 -4610 3020 -4610 {lab=rowoff_n[4]}
N 3020 -4610 3030 -4600 {lab=rowoff_n[4]}
N 3030 -4600 3160 -4600 {lab=rowoff_n[4]}
N 2810 -4580 2820 -4590 {lab=row_n[4]}
N 2820 -4590 3020 -4590 {lab=row_n[4]}
N 3020 -4590 3030 -4580 {lab=row_n[4]}
N 3030 -4580 3160 -4580 {lab=row_n[4]}
N 2810 -4560 2820 -4570 {lab=rowon_n[4]}
N 2820 -4570 3020 -4570 {lab=rowon_n[4]}
N 3020 -4570 3030 -4560 {lab=rowon_n[4]}
N 3030 -4560 3160 -4560 {lab=rowon_n[4]}
N 2810 -4540 2820 -4550 {lab=#net7}
N 2820 -4550 3020 -4550 {lab=#net7}
N 3020 -4550 3030 -4540 {lab=#net7}
N 3030 -4540 3160 -4540 {lab=#net7}
N 2810 -4520 2820 -4530 {lab=#net8}
N 2820 -4530 3020 -4530 {lab=#net8}
N 3020 -4530 3030 -4520 {lab=#net8}
N 3030 -4520 3160 -4520 {lab=#net8}
N 3160 -4600 3170 -4610 {lab=rowoff_n[4]}
N 3170 -4610 3370 -4610 {lab=rowoff_n[4]}
N 3370 -4610 3380 -4600 {lab=rowoff_n[4]}
N 3380 -4600 3510 -4600 {lab=rowoff_n[4]}
N 3160 -4580 3170 -4590 {lab=row_n[4]}
N 3170 -4590 3370 -4590 {lab=row_n[4]}
N 3370 -4590 3380 -4580 {lab=row_n[4]}
N 3380 -4580 3510 -4580 {lab=row_n[4]}
N 3160 -4560 3170 -4570 {lab=rowon_n[4]}
N 3170 -4570 3370 -4570 {lab=rowon_n[4]}
N 3370 -4570 3380 -4560 {lab=rowon_n[4]}
N 3380 -4560 3510 -4560 {lab=rowon_n[4]}
N 3370 -4550 3380 -4540 {lab=#net7}
N 3380 -4540 3510 -4540 {lab=#net7}
N 3160 -4520 3170 -4530 {lab=#net8}
N 3170 -4530 3370 -4530 {lab=#net8}
N 3370 -4530 3380 -4520 {lab=#net8}
N 3380 -4520 3510 -4520 {lab=#net8}
N 3160 -4540 3170 -4550 {lab=#net7}
N 3170 -4550 3370 -4550 {lab=#net7}
N 3510 -4600 3520 -4610 {lab=rowoff_n[4]}
N 3520 -4610 3720 -4610 {lab=rowoff_n[4]}
N 3720 -4610 3730 -4600 {lab=rowoff_n[4]}
N 3730 -4600 3850 -4600 {lab=rowoff_n[4]}
N 3510 -4580 3520 -4590 {lab=row_n[4]}
N 3520 -4590 3720 -4590 {lab=row_n[4]}
N 3720 -4590 3730 -4580 {lab=row_n[4]}
N 3730 -4580 3850 -4580 {lab=row_n[4]}
N 3510 -4560 3520 -4570 {lab=rowon_n[4]}
N 3520 -4570 3720 -4570 {lab=rowon_n[4]}
N 3720 -4570 3730 -4560 {lab=rowon_n[4]}
N 3730 -4560 3850 -4560 {lab=rowon_n[4]}
N 3510 -4540 3520 -4550 {lab=#net7}
N 3520 -4550 3720 -4550 {lab=#net7}
N 3720 -4550 3730 -4540 {lab=#net7}
N 3730 -4540 3850 -4540 {lab=#net7}
N 3510 -4520 3520 -4530 {lab=#net8}
N 3520 -4530 3720 -4530 {lab=#net8}
N 3720 -4530 3730 -4520 {lab=#net8}
N 3730 -4520 3850 -4520 {lab=#net8}
N 3850 -4600 3860 -4610 {lab=rowoff_n[4]}
N 3860 -4610 4060 -4610 {lab=rowoff_n[4]}
N 4060 -4610 4070 -4600 {lab=rowoff_n[4]}
N 4070 -4600 4200 -4600 {lab=rowoff_n[4]}
N 3850 -4580 3860 -4590 {lab=row_n[4]}
N 3860 -4590 4060 -4590 {lab=row_n[4]}
N 4060 -4590 4070 -4580 {lab=row_n[4]}
N 4070 -4580 4200 -4580 {lab=row_n[4]}
N 3850 -4560 3860 -4570 {lab=rowon_n[4]}
N 3860 -4570 4060 -4570 {lab=rowon_n[4]}
N 4060 -4570 4070 -4560 {lab=rowon_n[4]}
N 4070 -4560 4200 -4560 {lab=rowon_n[4]}
N 3850 -4540 3860 -4550 {lab=#net7}
N 3860 -4550 4060 -4550 {lab=#net7}
N 3850 -4520 3860 -4530 {lab=#net8}
N 3860 -4530 4060 -4530 {lab=#net8}
N 4060 -4530 4070 -4520 {lab=#net8}
N 4070 -4520 4200 -4520 {lab=#net8}
N 4060 -4550 4070 -4540 {lab=#net7}
N 4070 -4540 4200 -4540 {lab=#net7}
N 4200 -4600 4210 -4610 {lab=rowoff_n[4]}
N 4210 -4610 4410 -4610 {lab=rowoff_n[4]}
N 4410 -4610 4420 -4600 {lab=rowoff_n[4]}
N 4420 -4600 4560 -4600 {lab=rowoff_n[4]}
N 4200 -4580 4210 -4590 {lab=row_n[4]}
N 4210 -4590 4410 -4590 {lab=row_n[4]}
N 4410 -4590 4420 -4580 {lab=row_n[4]}
N 4420 -4580 4560 -4580 {lab=row_n[4]}
N 4200 -4560 4210 -4570 {lab=rowon_n[4]}
N 4210 -4570 4410 -4570 {lab=rowon_n[4]}
N 4410 -4570 4420 -4560 {lab=rowon_n[4]}
N 4420 -4560 4560 -4560 {lab=rowon_n[4]}
N 4200 -4540 4210 -4550 {lab=#net7}
N 4210 -4550 4410 -4550 {lab=#net7}
N 4410 -4550 4420 -4540 {lab=#net7}
N 4420 -4540 4560 -4540 {lab=#net7}
N 4200 -4520 4210 -4530 {lab=#net8}
N 4210 -4530 4410 -4530 {lab=#net8}
N 4410 -4530 4420 -4520 {lab=#net8}
N 4420 -4520 4560 -4520 {lab=#net8}
N 4560 -4600 4570 -4610 {lab=rowoff_n[4]}
N 4570 -4610 4770 -4610 {lab=rowoff_n[4]}
N 4770 -4610 4780 -4600 {lab=rowoff_n[4]}
N 4780 -4600 4890 -4600 {lab=rowoff_n[4]}
N 4560 -4580 4570 -4590 {lab=row_n[4]}
N 4570 -4590 4770 -4590 {lab=row_n[4]}
N 4770 -4590 4780 -4580 {lab=row_n[4]}
N 4780 -4580 4890 -4580 {lab=row_n[4]}
N 4560 -4560 4570 -4570 {lab=rowon_n[4]}
N 4570 -4570 4770 -4570 {lab=rowon_n[4]}
N 4770 -4570 4780 -4560 {lab=rowon_n[4]}
N 4780 -4560 4890 -4560 {lab=rowon_n[4]}
N 4560 -4540 4570 -4550 {lab=#net7}
N 4570 -4550 4770 -4550 {lab=#net7}
N 4770 -4550 4780 -4540 {lab=#net7}
N 4780 -4540 4890 -4540 {lab=#net7}
N 4560 -4520 4570 -4530 {lab=#net8}
N 4570 -4530 4770 -4530 {lab=#net8}
N 4770 -4530 4780 -4520 {lab=#net8}
N 4780 -4520 4890 -4520 {lab=#net8}
N 4890 -4600 4900 -4610 {lab=rowoff_n[4]}
N 4900 -4610 5100 -4610 {lab=rowoff_n[4]}
N 5100 -4610 5110 -4600 {lab=rowoff_n[4]}
N 5110 -4600 5220 -4600 {lab=rowoff_n[4]}
N 4890 -4580 4900 -4590 {lab=row_n[4]}
N 4900 -4590 5100 -4590 {lab=row_n[4]}
N 5100 -4590 5110 -4580 {lab=row_n[4]}
N 5110 -4580 5220 -4580 {lab=row_n[4]}
N 4890 -4560 4900 -4570 {lab=rowon_n[4]}
N 4900 -4570 5100 -4570 {lab=rowon_n[4]}
N 5100 -4570 5110 -4560 {lab=rowon_n[4]}
N 5110 -4560 5220 -4560 {lab=rowon_n[4]}
N 4890 -4540 4900 -4550 {lab=#net7}
N 4900 -4550 5100 -4550 {lab=#net7}
N 5100 -4550 5110 -4540 {lab=#net7}
N 5110 -4540 5220 -4540 {lab=#net7}
N 4890 -4520 4900 -4530 {lab=#net8}
N 4900 -4530 5100 -4530 {lab=#net8}
N 5100 -4530 5120 -4520 {lab=#net8}
N 5120 -4520 5220 -4520 {lab=#net8}
N 5220 -4600 5230 -4610 {lab=rowoff_n[4]}
N 5230 -4610 5430 -4610 {lab=rowoff_n[4]}
N 5430 -4610 5440 -4600 {lab=rowoff_n[4]}
N 5440 -4600 5570 -4600 {lab=rowoff_n[4]}
N 5220 -4580 5230 -4590 {lab=row_n[4]}
N 5230 -4590 5430 -4590 {lab=row_n[4]}
N 5430 -4590 5440 -4580 {lab=row_n[4]}
N 5440 -4580 5570 -4580 {lab=row_n[4]}
N 5220 -4560 5230 -4570 {lab=rowon_n[4]}
N 5230 -4570 5430 -4570 {lab=rowon_n[4]}
N 5430 -4570 5440 -4560 {lab=rowon_n[4]}
N 5440 -4560 5570 -4560 {lab=rowon_n[4]}
N 5220 -4540 5230 -4550 {lab=#net7}
N 5230 -4550 5430 -4550 {lab=#net7}
N 5430 -4550 5440 -4540 {lab=#net7}
N 5440 -4540 5570 -4540 {lab=#net7}
N 5220 -4520 5230 -4530 {lab=#net8}
N 5230 -4530 5430 -4530 {lab=#net8}
N 5430 -4530 5440 -4520 {lab=#net8}
N 5440 -4520 5570 -4520 {lab=#net8}
N 5570 -4600 5580 -4610 {lab=rowoff_n[4]}
N 5580 -4610 5780 -4610 {lab=rowoff_n[4]}
N 5780 -4610 5790 -4600 {lab=rowoff_n[4]}
N 5790 -4600 5920 -4600 {lab=rowoff_n[4]}
N 5570 -4580 5580 -4590 {lab=row_n[4]}
N 5580 -4590 5780 -4590 {lab=row_n[4]}
N 5570 -4560 5580 -4570 {lab=rowon_n[4]}
N 5580 -4570 5780 -4570 {lab=rowon_n[4]}
N 5780 -4570 5790 -4560 {lab=rowon_n[4]}
N 5790 -4560 5920 -4560 {lab=rowon_n[4]}
N 5780 -4590 5790 -4580 {lab=row_n[4]}
N 5790 -4580 5920 -4580 {lab=row_n[4]}
N 5570 -4540 5580 -4550 {lab=#net7}
N 5580 -4550 5780 -4550 {lab=#net7}
N 5780 -4550 5790 -4540 {lab=#net7}
N 5790 -4540 5920 -4540 {lab=#net7}
N 5570 -4520 5580 -4530 {lab=#net8}
N 5580 -4530 5780 -4530 {lab=#net8}
N 5780 -4530 5790 -4520 {lab=#net8}
N 5790 -4520 5920 -4520 {lab=#net8}
N 5920 -4600 5930 -4610 {lab=rowoff_n[4]}
N 5930 -4610 6130 -4610 {lab=rowoff_n[4]}
N 6130 -4610 6140 -4600 {lab=rowoff_n[4]}
N 6140 -4600 6260 -4600 {lab=rowoff_n[4]}
N 5920 -4580 5930 -4590 {lab=row_n[4]}
N 5930 -4590 6130 -4590 {lab=row_n[4]}
N 6130 -4590 6140 -4580 {lab=row_n[4]}
N 6140 -4580 6260 -4580 {lab=row_n[4]}
N 5920 -4560 5930 -4570 {lab=rowon_n[4]}
N 5930 -4570 6130 -4570 {lab=rowon_n[4]}
N 6130 -4570 6140 -4560 {lab=rowon_n[4]}
N 6140 -4560 6260 -4560 {lab=rowon_n[4]}
N 5920 -4540 5930 -4550 {lab=#net7}
N 5930 -4550 6130 -4550 {lab=#net7}
N 6130 -4550 6140 -4540 {lab=#net7}
N 6140 -4540 6260 -4540 {lab=#net7}
N 5920 -4520 5930 -4530 {lab=#net8}
N 5930 -4530 6130 -4530 {lab=#net8}
N 6130 -4530 6140 -4520 {lab=#net8}
N 6140 -4520 6260 -4520 {lab=#net8}
N 6260 -4600 6270 -4610 {lab=rowoff_n[4]}
N 6270 -4610 6470 -4610 {lab=rowoff_n[4]}
N 6470 -4610 6480 -4600 {lab=rowoff_n[4]}
N 6480 -4600 6600 -4600 {lab=rowoff_n[4]}
N 6260 -4580 6270 -4590 {lab=row_n[4]}
N 6270 -4590 6470 -4590 {lab=row_n[4]}
N 6470 -4590 6480 -4580 {lab=row_n[4]}
N 6480 -4580 6600 -4580 {lab=row_n[4]}
N 6260 -4560 6270 -4570 {lab=rowon_n[4]}
N 6270 -4570 6470 -4570 {lab=rowon_n[4]}
N 6470 -4570 6480 -4560 {lab=rowon_n[4]}
N 6480 -4560 6600 -4560 {lab=rowon_n[4]}
N 6260 -4540 6270 -4550 {lab=#net7}
N 6270 -4550 6470 -4550 {lab=#net7}
N 6470 -4550 6480 -4540 {lab=#net7}
N 6480 -4540 6600 -4540 {lab=#net7}
N 6260 -4520 6270 -4530 {lab=#net8}
N 6270 -4530 6470 -4530 {lab=#net8}
N 6470 -4530 6490 -4520 {lab=#net8}
N 6490 -4520 6600 -4520 {lab=#net8}
N 6600 -4600 6610 -4610 {lab=rowoff_n[4]}
N 6610 -4610 6810 -4610 {lab=rowoff_n[4]}
N 6600 -4580 6610 -4590 {lab=row_n[4]}
N 6610 -4590 6810 -4590 {lab=row_n[4]}
N 6810 -4590 6820 -4580 {lab=row_n[4]}
N 6810 -4610 6820 -4600 {lab=rowoff_n[4]}
N 6600 -4560 6610 -4570 {lab=rowon_n[4]}
N 6610 -4570 6810 -4570 {lab=rowon_n[4]}
N 6600 -4540 6610 -4550 {lab=#net7}
N 6610 -4550 6810 -4550 {lab=#net7}
N 6810 -4550 6820 -4540 {lab=#net7}
N 6600 -4520 6610 -4530 {lab=#net8}
N 6610 -4530 6810 -4530 {lab=#net8}
N 6810 -4530 6820 -4520 {lab=#net8}
N 6810 -4570 6820 -4560 {lab=rowon_n[4]}
N 1930 -4110 1940 -4120 {lab=VDD}
N 1940 -4370 1940 -4120 {lab=VDD}
N 1930 -4380 1940 -4370 {lab=VDD}
N 1930 -4440 1930 -4380 {lab=VDD}
N 1950 -4440 1950 -4380 {lab=VSS}
N 1950 -4380 1960 -4370 {lab=VSS}
N 1960 -4370 1960 -4120 {lab=VSS}
N 1950 -4110 1960 -4120 {lab=VSS}
N 2260 -4370 2260 -4120 {lab=col_n[0]}
N 2250 -4380 2260 -4370 {lab=col_n[0]}
N 2250 -4440 2250 -4380 {lab=col_n[0]}
N 2270 -4440 2270 -4380 {lab=col[0]}
N 2270 -4380 2280 -4370 {lab=col[0]}
N 2280 -4370 2280 -4120 {lab=col[0]}
N 2590 -4370 2590 -4120 {lab=col_n[1]}
N 2580 -4380 2590 -4370 {lab=col_n[1]}
N 2580 -4440 2580 -4380 {lab=col_n[1]}
N 2600 -4440 2600 -4380 {lab=col[1]}
N 2600 -4380 2610 -4370 {lab=col[1]}
N 2610 -4370 2610 -4120 {lab=col[1]}
N 2940 -4370 2940 -4120 {lab=col_n[2]}
N 2930 -4380 2940 -4370 {lab=col_n[2]}
N 2930 -4440 2930 -4380 {lab=col_n[2]}
N 2950 -4440 2950 -4380 {lab=col[2]}
N 2950 -4380 2960 -4370 {lab=col[2]}
N 2960 -4370 2960 -4120 {lab=col[2]}
N 3290 -4370 3290 -4120 {lab=col_n[3]}
N 3280 -4380 3290 -4370 {lab=col_n[3]}
N 3280 -4440 3280 -4380 {lab=col_n[3]}
N 3300 -4440 3300 -4380 {lab=col[3]}
N 3300 -4380 3310 -4370 {lab=col[3]}
N 3310 -4370 3310 -4120 {lab=col[3]}
N 3640 -4370 3640 -4120 {lab=col_n[4]}
N 3630 -4380 3640 -4370 {lab=col_n[4]}
N 3630 -4440 3630 -4380 {lab=col_n[4]}
N 3650 -4440 3650 -4380 {lab=col[4]}
N 3650 -4380 3660 -4370 {lab=col[4]}
N 3660 -4370 3660 -4120 {lab=col[4]}
N 3980 -4370 3980 -4120 {lab=col_n[5]}
N 3970 -4380 3980 -4370 {lab=col_n[5]}
N 3970 -4440 3970 -4380 {lab=col_n[5]}
N 3990 -4440 3990 -4380 {lab=col[5]}
N 3990 -4380 4000 -4370 {lab=col[5]}
N 4000 -4370 4000 -4120 {lab=col[5]}
N 4330 -4370 4330 -4120 {lab=col_n[6]}
N 4320 -4380 4330 -4370 {lab=col_n[6]}
N 4320 -4440 4320 -4380 {lab=col_n[6]}
N 4340 -4440 4340 -4380 {lab=col[6]}
N 4340 -4380 4350 -4370 {lab=col[6]}
N 4350 -4370 4350 -4120 {lab=col[6]}
N 4690 -4370 4690 -4120 {lab=col_n[7]}
N 4680 -4380 4690 -4370 {lab=col_n[7]}
N 4680 -4440 4680 -4380 {lab=col_n[7]}
N 4700 -4440 4700 -4380 {lab=col[7]}
N 4700 -4380 4710 -4370 {lab=col[7]}
N 4710 -4370 4710 -4120 {lab=col[7]}
N 5020 -4370 5020 -4120 {lab=col_n[8]}
N 5010 -4380 5020 -4370 {lab=col_n[8]}
N 5010 -4440 5010 -4380 {lab=col_n[8]}
N 5030 -4440 5030 -4380 {lab=col[8]}
N 5030 -4380 5040 -4370 {lab=col[8]}
N 5040 -4370 5040 -4120 {lab=col[8]}
N 5350 -4370 5350 -4120 {lab=col_n[9]}
N 5340 -4380 5350 -4370 {lab=col_n[9]}
N 5340 -4440 5340 -4380 {lab=col_n[9]}
N 5360 -4440 5360 -4380 {lab=col[9]}
N 5360 -4380 5370 -4370 {lab=col[9]}
N 5370 -4370 5370 -4120 {lab=col[9]}
N 5700 -4370 5700 -4120 {lab=col_n[10]}
N 5690 -4380 5700 -4370 {lab=col_n[10]}
N 5690 -4440 5690 -4380 {lab=col_n[10]}
N 5710 -4440 5710 -4380 {lab=col[10]}
N 5710 -4380 5720 -4370 {lab=col[10]}
N 5720 -4370 5720 -4120 {lab=col[10]}
N 6050 -4370 6050 -4120 {lab=col_n[11]}
N 6040 -4380 6050 -4370 {lab=col_n[11]}
N 6040 -4440 6040 -4380 {lab=col_n[11]}
N 6060 -4440 6060 -4380 {lab=col[11]}
N 6060 -4380 6070 -4370 {lab=col[11]}
N 6070 -4370 6070 -4120 {lab=col[11]}
N 6390 -4370 6390 -4120 {lab=col_n[12]}
N 6380 -4380 6390 -4370 {lab=col_n[12]}
N 6380 -4440 6380 -4380 {lab=col_n[12]}
N 6400 -4440 6400 -4380 {lab=col[12]}
N 6400 -4380 6410 -4370 {lab=col[12]}
N 6410 -4370 6410 -4120 {lab=col[12]}
N 6730 -4370 6730 -4120 {lab=VDD}
N 6720 -4380 6730 -4370 {lab=VDD}
N 6720 -4440 6720 -4380 {lab=VDD}
N 6740 -4440 6740 -4380 {lab=VSS}
N 6740 -4380 6750 -4370 {lab=VSS}
N 6750 -4370 6750 -4120 {lab=VSS}
N 6740 -4110 6750 -4120 {lab=VSS}
N 6720 -4110 6730 -4120 {lab=VDD}
N 6380 -4110 6390 -4120 {lab=col_n[12]}
N 6400 -4110 6410 -4120 {lab=col[12]}
N 6040 -4110 6050 -4120 {lab=col_n[11]}
N 6060 -4110 6070 -4120 {lab=col[11]}
N 5690 -4110 5700 -4120 {lab=col_n[10]}
N 5710 -4110 5720 -4120 {lab=col[10]}
N 5360 -4110 5370 -4120 {lab=col[9]}
N 5340 -4110 5350 -4120 {lab=col_n[9]}
N 5030 -4110 5040 -4120 {lab=col[8]}
N 5010 -4110 5020 -4120 {lab=col_n[8]}
N 4680 -4110 4690 -4120 {lab=col_n[7]}
N 4700 -4110 4710 -4120 {lab=col[7]}
N 4320 -4110 4330 -4120 {lab=col_n[6]}
N 4340 -4110 4350 -4120 {lab=col[6]}
N 3990 -4110 4000 -4120 {lab=col[5]}
N 3970 -4110 3980 -4120 {lab=col_n[5]}
N 3650 -4110 3660 -4120 {lab=col[4]}
N 3630 -4110 3640 -4120 {lab=col_n[4]}
N 3300 -4110 3310 -4120 {lab=col[3]}
N 3280 -4110 3290 -4120 {lab=col_n[3]}
N 2950 -4110 2960 -4120 {lab=col[2]}
N 2930 -4110 2940 -4120 {lab=col_n[2]}
N 2600 -4110 2610 -4120 {lab=col[1]}
N 2580 -4110 2590 -4120 {lab=col_n[1]}
N 2250 -4110 2260 -4120 {lab=col_n[0]}
N 2270 -4110 2280 -4120 {lab=col[0]}
N 1930 -4110 1930 -4070 {lab=VDD}
N 1950 -4110 1950 -4070 {lab=VSS}
N 1930 -3790 1940 -3800 {lab=VDD}
N 1940 -4060 1940 -3800 {lab=VDD}
N 1930 -4070 1940 -4060 {lab=VDD}
N 1950 -4070 1960 -4060 {lab=VSS}
N 1960 -4060 1960 -3800 {lab=VSS}
N 1950 -3790 1960 -3800 {lab=VSS}
N 2250 -4110 2250 -4070 {lab=col_n[0]}
N 2270 -4110 2270 -4070 {lab=col[0]}
N 2260 -4060 2260 -3800 {lab=col_n[0]}
N 2250 -4070 2260 -4060 {lab=col_n[0]}
N 2270 -4070 2280 -4060 {lab=col[0]}
N 2280 -4060 2280 -3800 {lab=col[0]}
N 2580 -4110 2580 -4070 {lab=col_n[1]}
N 2600 -4110 2600 -4070 {lab=col[1]}
N 2590 -4060 2590 -3800 {lab=col_n[1]}
N 2580 -4070 2590 -4060 {lab=col_n[1]}
N 2600 -4070 2610 -4060 {lab=col[1]}
N 2610 -4060 2610 -3800 {lab=col[1]}
N 2930 -4110 2930 -4070 {lab=col_n[2]}
N 2950 -4110 2950 -4070 {lab=col[2]}
N 2940 -4060 2940 -3800 {lab=col_n[2]}
N 2930 -4070 2940 -4060 {lab=col_n[2]}
N 2950 -4070 2960 -4060 {lab=col[2]}
N 2960 -4060 2960 -3800 {lab=col[2]}
N 3280 -4110 3280 -4070 {lab=col_n[3]}
N 3300 -4110 3300 -4070 {lab=col[3]}
N 3290 -4060 3290 -3800 {lab=col_n[3]}
N 3280 -4070 3290 -4060 {lab=col_n[3]}
N 3300 -4070 3310 -4060 {lab=col[3]}
N 3310 -4060 3310 -3800 {lab=col[3]}
N 3630 -4110 3630 -4070 {lab=col_n[4]}
N 3650 -4110 3650 -4070 {lab=col[4]}
N 3640 -4060 3640 -3800 {lab=col_n[4]}
N 3630 -4070 3640 -4060 {lab=col_n[4]}
N 3650 -4070 3660 -4060 {lab=col[4]}
N 3660 -4060 3660 -3800 {lab=col[4]}
N 3970 -4110 3970 -4070 {lab=col_n[5]}
N 3990 -4110 3990 -4070 {lab=col[5]}
N 3980 -4060 3980 -3800 {lab=col_n[5]}
N 3970 -4070 3980 -4060 {lab=col_n[5]}
N 3990 -4070 4000 -4060 {lab=col[5]}
N 4000 -4060 4000 -3800 {lab=col[5]}
N 4320 -4110 4320 -4070 {lab=col_n[6]}
N 4340 -4110 4340 -4070 {lab=col[6]}
N 4330 -4060 4330 -3800 {lab=col_n[6]}
N 4320 -4070 4330 -4060 {lab=col_n[6]}
N 4340 -4070 4350 -4060 {lab=col[6]}
N 4350 -4060 4350 -3800 {lab=col[6]}
N 4680 -4110 4680 -4070 {lab=col_n[7]}
N 4700 -4110 4700 -4070 {lab=col[7]}
N 4690 -4060 4690 -3800 {lab=col_n[7]}
N 4680 -4070 4690 -4060 {lab=col_n[7]}
N 4700 -4070 4710 -4060 {lab=col[7]}
N 4710 -4060 4710 -3800 {lab=col[7]}
N 5010 -4110 5010 -4070 {lab=col_n[8]}
N 5030 -4110 5030 -4070 {lab=col[8]}
N 5020 -4060 5020 -3800 {lab=col_n[8]}
N 5010 -4070 5020 -4060 {lab=col_n[8]}
N 5030 -4070 5040 -4060 {lab=col[8]}
N 5040 -4060 5040 -3800 {lab=col[8]}
N 5690 -4110 5690 -4070 {lab=col_n[10]}
N 5710 -4110 5710 -4070 {lab=col[10]}
N 5700 -4060 5700 -3800 {lab=col_n[10]}
N 5690 -4070 5700 -4060 {lab=col_n[10]}
N 5710 -4070 5720 -4060 {lab=col[10]}
N 5720 -4060 5720 -3800 {lab=col[10]}
N 6040 -4110 6040 -4070 {lab=col_n[11]}
N 6060 -4110 6060 -4070 {lab=col[11]}
N 6050 -4060 6050 -3800 {lab=col_n[11]}
N 6040 -4070 6050 -4060 {lab=col_n[11]}
N 6060 -4070 6070 -4060 {lab=col[11]}
N 6070 -4060 6070 -3800 {lab=col[11]}
N 6380 -4110 6380 -4070 {lab=col_n[12]}
N 6400 -4110 6400 -4070 {lab=col[12]}
N 6390 -4060 6390 -3800 {lab=col_n[12]}
N 6380 -4070 6390 -4060 {lab=col_n[12]}
N 6400 -4070 6410 -4060 {lab=col[12]}
N 6410 -4060 6410 -3800 {lab=col[12]}
N 6720 -4110 6720 -4070 {lab=VDD}
N 6740 -4110 6740 -4070 {lab=VSS}
N 6730 -4060 6730 -3800 {lab=VDD}
N 6720 -4070 6730 -4060 {lab=VDD}
N 6740 -4070 6750 -4060 {lab=VSS}
N 6750 -4060 6750 -3800 {lab=VSS}
N 6740 -3790 6750 -3800 {lab=VSS}
N 6720 -3790 6730 -3800 {lab=VDD}
N 6400 -3790 6410 -3800 {lab=col[12]}
N 6380 -3790 6390 -3800 {lab=col_n[12]}
N 6060 -3790 6070 -3800 {lab=col[11]}
N 6040 -3790 6050 -3800 {lab=col_n[11]}
N 5710 -3790 5720 -3800 {lab=col[10]}
N 5690 -3790 5700 -3800 {lab=col_n[10]}
N 5340 -4110 5340 -4070 {lab=col_n[9]}
N 5360 -4110 5360 -4070 {lab=col[9]}
N 5350 -4060 5350 -3800 {lab=col_n[9]}
N 5340 -4070 5350 -4060 {lab=col_n[9]}
N 5360 -4070 5370 -4060 {lab=col[9]}
N 5370 -4060 5370 -3800 {lab=col[9]}
N 5360 -3790 5370 -3800 {lab=col[9]}
N 5340 -3790 5350 -3800 {lab=col_n[9]}
N 5030 -3790 5040 -3800 {lab=col[8]}
N 5010 -3790 5020 -3800 {lab=col_n[8]}
N 4700 -3790 4710 -3800 {lab=col[7]}
N 4680 -3790 4690 -3800 {lab=col_n[7]}
N 4340 -3790 4350 -3800 {lab=col[6]}
N 4320 -3790 4330 -3800 {lab=col_n[6]}
N 3990 -3790 4000 -3800 {lab=col[5]}
N 3970 -3790 3980 -3800 {lab=col_n[5]}
N 3650 -3790 3660 -3800 {lab=col[4]}
N 3630 -3790 3640 -3800 {lab=col_n[4]}
N 2250 -3790 2260 -3800 {lab=col_n[0]}
N 2270 -3790 2280 -3800 {lab=col[0]}
N 2580 -3790 2590 -3800 {lab=col_n[1]}
N 2600 -3790 2610 -3800 {lab=col[1]}
N 2930 -3790 2940 -3800 {lab=col_n[2]}
N 2950 -3790 2960 -3800 {lab=col[2]}
N 3280 -3790 3290 -3800 {lab=col_n[3]}
N 3300 -3790 3310 -3800 {lab=col[3]}
N 1850 -4790 1850 -4780 {
lab=VSS}
N 2170 -4790 2170 -4780 {
lab=VSS}
N 2500 -4790 2500 -4780 {
lab=VSS}
N 2850 -4790 2850 -4780 {
lab=VSS}
N 3200 -4790 3200 -4780 {
lab=VSS}
N 3550 -4790 3550 -4780 {
lab=VSS}
N 3890 -4790 3890 -4780 {
lab=VSS}
N 4240 -4790 4240 -4780 {
lab=VSS}
N 4600 -4790 4600 -4780 {
lab=VSS}
N 4930 -4790 4930 -4780 {
lab=VSS}
N 5260 -4790 5260 -4780 {
lab=VSS}
N 5610 -4790 5610 -4780 {
lab=VSS}
N 5960 -4790 5960 -4780 {
lab=VSS}
N 6300 -4790 6300 -4780 {
lab=VSS}
N 6640 -4790 6640 -4780 {
lab=VSS}
N 6660 -5030 6660 -5010 {
lab=vcm}
N 6640 -5020 6640 -5010 {
lab=VDD}
N 6700 -5030 6700 -5010 {
lab=ctop}
N 5980 -5030 5980 -5010 {
lab=vcm}
N 5960 -5020 5960 -5010 {
lab=VDD}
N 6020 -5030 6020 -5010 {
lab=ctop}
N 6320 -5030 6320 -5010 {
lab=vcm}
N 6300 -5020 6300 -5010 {
lab=VDD}
N 6360 -5030 6360 -5010 {
lab=ctop}
N 5630 -5030 5630 -5010 {
lab=vcm}
N 5610 -5020 5610 -5010 {
lab=VDD}
N 5670 -5030 5670 -5010 {
lab=ctop}
N 5280 -5030 5280 -5010 {
lab=vcm}
N 5260 -5020 5260 -5010 {
lab=VDD}
N 5320 -5030 5320 -5010 {
lab=ctop}
N 4950 -5030 4950 -5010 {
lab=vcm}
N 4930 -5020 4930 -5010 {
lab=VDD}
N 4990 -5030 4990 -5010 {
lab=ctop}
N 4620 -5030 4620 -5010 {
lab=vcm}
N 4600 -5020 4600 -5010 {
lab=VDD}
N 4660 -5030 4660 -5010 {
lab=ctop}
N 4260 -5030 4260 -5010 {
lab=vcm}
N 4240 -5020 4240 -5010 {
lab=VDD}
N 4300 -5030 4300 -5010 {
lab=ctop}
N 3910 -5030 3910 -5010 {
lab=vcm}
N 3890 -5020 3890 -5010 {
lab=VDD}
N 3950 -5030 3950 -5010 {
lab=ctop}
N 3570 -5030 3570 -5010 {
lab=vcm}
N 3550 -5020 3550 -5010 {
lab=VDD}
N 3610 -5030 3610 -5010 {
lab=ctop}
N 3220 -5030 3220 -5010 {
lab=vcm}
N 3200 -5020 3200 -5010 {
lab=VDD}
N 3260 -5030 3260 -5010 {
lab=ctop}
N 2870 -5030 2870 -5010 {
lab=vcm}
N 2850 -5020 2850 -5010 {
lab=VDD}
N 2910 -5030 2910 -5010 {
lab=ctop}
N 2520 -5030 2520 -5010 {
lab=vcm}
N 2500 -5020 2500 -5010 {
lab=VDD}
N 2560 -5030 2560 -5010 {
lab=ctop}
N 2190 -5030 2190 -5010 {
lab=vcm}
N 2170 -5020 2170 -5010 {
lab=VDD}
N 2230 -5030 2230 -5010 {
lab=ctop}
N 1870 -5030 1870 -5010 {
lab=vcm}
N 1850 -5020 1850 -5010 {
lab=VDD}
N 1910 -5030 1910 -5010 {
lab=ctop}
N 1790 -4870 1810 -4870 {
lab=sample_n}
N 1790 -4890 1810 -4890 {
lab=sample}
N 1790 -4910 1810 -4910 {
lab=rowon_n[5]}
N 1790 -4930 1810 -4930 {
lab=row_n[5]}
N 1790 -4950 1810 -4950 {
lab=rowoff_n[5]}
N 2030 -4890 2130 -4890 {lab=#net9}
N 2030 -4870 2130 -4870 {lab=#net10}
N 1810 -4950 1820 -4960 {lab=rowoff_n[5]}
N 1820 -4960 2040 -4960 {lab=rowoff_n[5]}
N 2040 -4960 2050 -4950 {lab=rowoff_n[5]}
N 2050 -4950 2130 -4950 {lab=rowoff_n[5]}
N 1810 -4930 1820 -4940 {lab=row_n[5]}
N 1820 -4940 2040 -4940 {lab=row_n[5]}
N 2040 -4940 2050 -4930 {lab=row_n[5]}
N 2050 -4930 2130 -4930 {lab=row_n[5]}
N 1810 -4910 1820 -4920 {lab=rowon_n[5]}
N 1820 -4920 2040 -4920 {lab=rowon_n[5]}
N 2040 -4920 2050 -4910 {lab=rowon_n[5]}
N 2050 -4910 2130 -4910 {lab=rowon_n[5]}
N 2130 -4950 2140 -4960 {lab=rowoff_n[5]}
N 2130 -4930 2140 -4940 {lab=row_n[5]}
N 2140 -4940 2340 -4940 {lab=row_n[5]}
N 2340 -4940 2350 -4930 {lab=row_n[5]}
N 2350 -4930 2460 -4930 {lab=row_n[5]}
N 2140 -4960 2340 -4960 {lab=rowoff_n[5]}
N 2340 -4960 2350 -4950 {lab=rowoff_n[5]}
N 2350 -4950 2460 -4950 {lab=rowoff_n[5]}
N 2130 -4910 2140 -4920 {lab=rowon_n[5]}
N 2140 -4920 2340 -4920 {lab=rowon_n[5]}
N 2340 -4920 2350 -4910 {lab=rowon_n[5]}
N 2350 -4910 2460 -4910 {lab=rowon_n[5]}
N 2130 -4890 2140 -4900 {lab=#net9}
N 2140 -4900 2340 -4900 {lab=#net9}
N 2340 -4900 2350 -4890 {lab=#net9}
N 2350 -4890 2460 -4890 {lab=#net9}
N 2130 -4870 2140 -4880 {lab=#net10}
N 2140 -4880 2340 -4880 {lab=#net10}
N 2340 -4880 2350 -4870 {lab=#net10}
N 2350 -4870 2460 -4870 {lab=#net10}
N 2460 -4930 2470 -4940 {lab=row_n[5]}
N 2470 -4940 2670 -4940 {lab=row_n[5]}
N 2670 -4940 2680 -4930 {lab=row_n[5]}
N 2680 -4930 2810 -4930 {lab=row_n[5]}
N 2460 -4910 2470 -4920 {lab=rowon_n[5]}
N 2470 -4920 2670 -4920 {lab=rowon_n[5]}
N 2670 -4920 2680 -4910 {lab=rowon_n[5]}
N 2680 -4910 2810 -4910 {lab=rowon_n[5]}
N 2460 -4890 2470 -4900 {lab=#net9}
N 2470 -4900 2670 -4900 {lab=#net9}
N 2670 -4900 2680 -4890 {lab=#net9}
N 2680 -4890 2810 -4890 {lab=#net9}
N 2460 -4870 2480 -4880 {lab=#net10}
N 2480 -4880 2670 -4880 {lab=#net10}
N 2670 -4880 2680 -4870 {lab=#net10}
N 2680 -4870 2810 -4870 {lab=#net10}
N 2460 -4950 2470 -4960 {lab=rowoff_n[5]}
N 2470 -4960 2670 -4960 {lab=rowoff_n[5]}
N 2670 -4960 2680 -4950 {lab=rowoff_n[5]}
N 2680 -4950 2810 -4950 {lab=rowoff_n[5]}
N 2810 -4950 2820 -4960 {lab=rowoff_n[5]}
N 2820 -4960 3020 -4960 {lab=rowoff_n[5]}
N 3020 -4960 3030 -4950 {lab=rowoff_n[5]}
N 3030 -4950 3160 -4950 {lab=rowoff_n[5]}
N 2810 -4930 2820 -4940 {lab=row_n[5]}
N 2820 -4940 3020 -4940 {lab=row_n[5]}
N 3020 -4940 3030 -4930 {lab=row_n[5]}
N 3030 -4930 3160 -4930 {lab=row_n[5]}
N 2810 -4910 2820 -4920 {lab=rowon_n[5]}
N 2820 -4920 3020 -4920 {lab=rowon_n[5]}
N 3020 -4920 3030 -4910 {lab=rowon_n[5]}
N 3030 -4910 3160 -4910 {lab=rowon_n[5]}
N 2810 -4890 2820 -4900 {lab=#net9}
N 2820 -4900 3020 -4900 {lab=#net9}
N 3020 -4900 3030 -4890 {lab=#net9}
N 3030 -4890 3160 -4890 {lab=#net9}
N 2810 -4870 2820 -4880 {lab=#net10}
N 2820 -4880 3020 -4880 {lab=#net10}
N 3020 -4880 3030 -4870 {lab=#net10}
N 3030 -4870 3160 -4870 {lab=#net10}
N 3160 -4950 3170 -4960 {lab=rowoff_n[5]}
N 3170 -4960 3370 -4960 {lab=rowoff_n[5]}
N 3370 -4960 3380 -4950 {lab=rowoff_n[5]}
N 3380 -4950 3510 -4950 {lab=rowoff_n[5]}
N 3160 -4930 3170 -4940 {lab=row_n[5]}
N 3170 -4940 3370 -4940 {lab=row_n[5]}
N 3370 -4940 3380 -4930 {lab=row_n[5]}
N 3380 -4930 3510 -4930 {lab=row_n[5]}
N 3160 -4910 3170 -4920 {lab=rowon_n[5]}
N 3170 -4920 3370 -4920 {lab=rowon_n[5]}
N 3370 -4920 3380 -4910 {lab=rowon_n[5]}
N 3380 -4910 3510 -4910 {lab=rowon_n[5]}
N 3370 -4900 3380 -4890 {lab=#net9}
N 3380 -4890 3510 -4890 {lab=#net9}
N 3160 -4870 3170 -4880 {lab=#net10}
N 3170 -4880 3370 -4880 {lab=#net10}
N 3370 -4880 3380 -4870 {lab=#net10}
N 3380 -4870 3510 -4870 {lab=#net10}
N 3160 -4890 3170 -4900 {lab=#net9}
N 3170 -4900 3370 -4900 {lab=#net9}
N 3510 -4950 3520 -4960 {lab=rowoff_n[5]}
N 3520 -4960 3720 -4960 {lab=rowoff_n[5]}
N 3720 -4960 3730 -4950 {lab=rowoff_n[5]}
N 3730 -4950 3850 -4950 {lab=rowoff_n[5]}
N 3510 -4930 3520 -4940 {lab=row_n[5]}
N 3520 -4940 3720 -4940 {lab=row_n[5]}
N 3720 -4940 3730 -4930 {lab=row_n[5]}
N 3730 -4930 3850 -4930 {lab=row_n[5]}
N 3510 -4910 3520 -4920 {lab=rowon_n[5]}
N 3520 -4920 3720 -4920 {lab=rowon_n[5]}
N 3720 -4920 3730 -4910 {lab=rowon_n[5]}
N 3730 -4910 3850 -4910 {lab=rowon_n[5]}
N 3510 -4890 3520 -4900 {lab=#net9}
N 3520 -4900 3720 -4900 {lab=#net9}
N 3720 -4900 3730 -4890 {lab=#net9}
N 3730 -4890 3850 -4890 {lab=#net9}
N 3510 -4870 3520 -4880 {lab=#net10}
N 3520 -4880 3720 -4880 {lab=#net10}
N 3720 -4880 3730 -4870 {lab=#net10}
N 3730 -4870 3850 -4870 {lab=#net10}
N 3850 -4950 3860 -4960 {lab=rowoff_n[5]}
N 3860 -4960 4060 -4960 {lab=rowoff_n[5]}
N 4060 -4960 4070 -4950 {lab=rowoff_n[5]}
N 4070 -4950 4200 -4950 {lab=rowoff_n[5]}
N 3850 -4930 3860 -4940 {lab=row_n[5]}
N 3860 -4940 4060 -4940 {lab=row_n[5]}
N 4060 -4940 4070 -4930 {lab=row_n[5]}
N 4070 -4930 4200 -4930 {lab=row_n[5]}
N 3850 -4910 3860 -4920 {lab=rowon_n[5]}
N 3860 -4920 4060 -4920 {lab=rowon_n[5]}
N 4060 -4920 4070 -4910 {lab=rowon_n[5]}
N 4070 -4910 4200 -4910 {lab=rowon_n[5]}
N 3850 -4890 3860 -4900 {lab=#net9}
N 3860 -4900 4060 -4900 {lab=#net9}
N 3850 -4870 3860 -4880 {lab=#net10}
N 3860 -4880 4060 -4880 {lab=#net10}
N 4060 -4880 4070 -4870 {lab=#net10}
N 4070 -4870 4200 -4870 {lab=#net10}
N 4060 -4900 4070 -4890 {lab=#net9}
N 4070 -4890 4200 -4890 {lab=#net9}
N 4200 -4950 4210 -4960 {lab=rowoff_n[5]}
N 4210 -4960 4410 -4960 {lab=rowoff_n[5]}
N 4410 -4960 4420 -4950 {lab=rowoff_n[5]}
N 4420 -4950 4560 -4950 {lab=rowoff_n[5]}
N 4200 -4930 4210 -4940 {lab=row_n[5]}
N 4210 -4940 4410 -4940 {lab=row_n[5]}
N 4410 -4940 4420 -4930 {lab=row_n[5]}
N 4420 -4930 4560 -4930 {lab=row_n[5]}
N 4200 -4910 4210 -4920 {lab=rowon_n[5]}
N 4210 -4920 4410 -4920 {lab=rowon_n[5]}
N 4410 -4920 4420 -4910 {lab=rowon_n[5]}
N 4420 -4910 4560 -4910 {lab=rowon_n[5]}
N 4200 -4890 4210 -4900 {lab=#net9}
N 4210 -4900 4410 -4900 {lab=#net9}
N 4410 -4900 4420 -4890 {lab=#net9}
N 4420 -4890 4560 -4890 {lab=#net9}
N 4200 -4870 4210 -4880 {lab=#net10}
N 4210 -4880 4410 -4880 {lab=#net10}
N 4410 -4880 4420 -4870 {lab=#net10}
N 4420 -4870 4560 -4870 {lab=#net10}
N 4560 -4950 4570 -4960 {lab=rowoff_n[5]}
N 4570 -4960 4770 -4960 {lab=rowoff_n[5]}
N 4770 -4960 4780 -4950 {lab=rowoff_n[5]}
N 4780 -4950 4890 -4950 {lab=rowoff_n[5]}
N 4560 -4930 4570 -4940 {lab=row_n[5]}
N 4570 -4940 4770 -4940 {lab=row_n[5]}
N 4770 -4940 4780 -4930 {lab=row_n[5]}
N 4780 -4930 4890 -4930 {lab=row_n[5]}
N 4560 -4910 4570 -4920 {lab=rowon_n[5]}
N 4570 -4920 4770 -4920 {lab=rowon_n[5]}
N 4770 -4920 4780 -4910 {lab=rowon_n[5]}
N 4780 -4910 4890 -4910 {lab=rowon_n[5]}
N 4560 -4890 4570 -4900 {lab=#net9}
N 4570 -4900 4770 -4900 {lab=#net9}
N 4770 -4900 4780 -4890 {lab=#net9}
N 4780 -4890 4890 -4890 {lab=#net9}
N 4560 -4870 4570 -4880 {lab=#net10}
N 4570 -4880 4770 -4880 {lab=#net10}
N 4770 -4880 4780 -4870 {lab=#net10}
N 4780 -4870 4890 -4870 {lab=#net10}
N 4890 -4950 4900 -4960 {lab=rowoff_n[5]}
N 4900 -4960 5100 -4960 {lab=rowoff_n[5]}
N 5100 -4960 5110 -4950 {lab=rowoff_n[5]}
N 5110 -4950 5220 -4950 {lab=rowoff_n[5]}
N 4890 -4930 4900 -4940 {lab=row_n[5]}
N 4900 -4940 5100 -4940 {lab=row_n[5]}
N 5100 -4940 5110 -4930 {lab=row_n[5]}
N 5110 -4930 5220 -4930 {lab=row_n[5]}
N 4890 -4910 4900 -4920 {lab=rowon_n[5]}
N 4900 -4920 5100 -4920 {lab=rowon_n[5]}
N 5100 -4920 5110 -4910 {lab=rowon_n[5]}
N 5110 -4910 5220 -4910 {lab=rowon_n[5]}
N 4890 -4890 4900 -4900 {lab=#net9}
N 4900 -4900 5100 -4900 {lab=#net9}
N 5100 -4900 5110 -4890 {lab=#net9}
N 5110 -4890 5220 -4890 {lab=#net9}
N 4890 -4870 4900 -4880 {lab=#net10}
N 4900 -4880 5100 -4880 {lab=#net10}
N 5100 -4880 5120 -4870 {lab=#net10}
N 5120 -4870 5220 -4870 {lab=#net10}
N 5220 -4950 5230 -4960 {lab=rowoff_n[5]}
N 5230 -4960 5430 -4960 {lab=rowoff_n[5]}
N 5430 -4960 5440 -4950 {lab=rowoff_n[5]}
N 5440 -4950 5570 -4950 {lab=rowoff_n[5]}
N 5220 -4930 5230 -4940 {lab=row_n[5]}
N 5230 -4940 5430 -4940 {lab=row_n[5]}
N 5430 -4940 5440 -4930 {lab=row_n[5]}
N 5440 -4930 5570 -4930 {lab=row_n[5]}
N 5220 -4910 5230 -4920 {lab=rowon_n[5]}
N 5230 -4920 5430 -4920 {lab=rowon_n[5]}
N 5430 -4920 5440 -4910 {lab=rowon_n[5]}
N 5440 -4910 5570 -4910 {lab=rowon_n[5]}
N 5220 -4890 5230 -4900 {lab=#net9}
N 5230 -4900 5430 -4900 {lab=#net9}
N 5430 -4900 5440 -4890 {lab=#net9}
N 5440 -4890 5570 -4890 {lab=#net9}
N 5220 -4870 5230 -4880 {lab=#net10}
N 5230 -4880 5430 -4880 {lab=#net10}
N 5430 -4880 5440 -4870 {lab=#net10}
N 5440 -4870 5570 -4870 {lab=#net10}
N 5570 -4950 5580 -4960 {lab=rowoff_n[5]}
N 5580 -4960 5780 -4960 {lab=rowoff_n[5]}
N 5780 -4960 5790 -4950 {lab=rowoff_n[5]}
N 5790 -4950 5920 -4950 {lab=rowoff_n[5]}
N 5570 -4930 5580 -4940 {lab=row_n[5]}
N 5580 -4940 5780 -4940 {lab=row_n[5]}
N 5570 -4910 5580 -4920 {lab=rowon_n[5]}
N 5580 -4920 5780 -4920 {lab=rowon_n[5]}
N 5780 -4920 5790 -4910 {lab=rowon_n[5]}
N 5790 -4910 5920 -4910 {lab=rowon_n[5]}
N 5780 -4940 5790 -4930 {lab=row_n[5]}
N 5790 -4930 5920 -4930 {lab=row_n[5]}
N 5570 -4890 5580 -4900 {lab=#net9}
N 5580 -4900 5780 -4900 {lab=#net9}
N 5780 -4900 5790 -4890 {lab=#net9}
N 5790 -4890 5920 -4890 {lab=#net9}
N 5570 -4870 5580 -4880 {lab=#net10}
N 5580 -4880 5780 -4880 {lab=#net10}
N 5780 -4880 5790 -4870 {lab=#net10}
N 5790 -4870 5920 -4870 {lab=#net10}
N 5920 -4950 5930 -4960 {lab=rowoff_n[5]}
N 5930 -4960 6130 -4960 {lab=rowoff_n[5]}
N 6130 -4960 6140 -4950 {lab=rowoff_n[5]}
N 6140 -4950 6260 -4950 {lab=rowoff_n[5]}
N 5920 -4930 5930 -4940 {lab=row_n[5]}
N 5930 -4940 6130 -4940 {lab=row_n[5]}
N 6130 -4940 6140 -4930 {lab=row_n[5]}
N 6140 -4930 6260 -4930 {lab=row_n[5]}
N 5920 -4910 5930 -4920 {lab=rowon_n[5]}
N 5930 -4920 6130 -4920 {lab=rowon_n[5]}
N 6130 -4920 6140 -4910 {lab=rowon_n[5]}
N 6140 -4910 6260 -4910 {lab=rowon_n[5]}
N 5920 -4890 5930 -4900 {lab=#net9}
N 5930 -4900 6130 -4900 {lab=#net9}
N 6130 -4900 6140 -4890 {lab=#net9}
N 6140 -4890 6260 -4890 {lab=#net9}
N 5920 -4870 5930 -4880 {lab=#net10}
N 5930 -4880 6130 -4880 {lab=#net10}
N 6130 -4880 6140 -4870 {lab=#net10}
N 6140 -4870 6260 -4870 {lab=#net10}
N 6260 -4950 6270 -4960 {lab=rowoff_n[5]}
N 6270 -4960 6470 -4960 {lab=rowoff_n[5]}
N 6470 -4960 6480 -4950 {lab=rowoff_n[5]}
N 6480 -4950 6600 -4950 {lab=rowoff_n[5]}
N 6260 -4930 6270 -4940 {lab=row_n[5]}
N 6270 -4940 6470 -4940 {lab=row_n[5]}
N 6470 -4940 6480 -4930 {lab=row_n[5]}
N 6480 -4930 6600 -4930 {lab=row_n[5]}
N 6260 -4910 6270 -4920 {lab=rowon_n[5]}
N 6270 -4920 6470 -4920 {lab=rowon_n[5]}
N 6470 -4920 6480 -4910 {lab=rowon_n[5]}
N 6480 -4910 6600 -4910 {lab=rowon_n[5]}
N 6260 -4890 6270 -4900 {lab=#net9}
N 6270 -4900 6470 -4900 {lab=#net9}
N 6470 -4900 6480 -4890 {lab=#net9}
N 6480 -4890 6600 -4890 {lab=#net9}
N 6260 -4870 6270 -4880 {lab=#net10}
N 6270 -4880 6470 -4880 {lab=#net10}
N 6470 -4880 6490 -4870 {lab=#net10}
N 6490 -4870 6600 -4870 {lab=#net10}
N 6600 -4950 6610 -4960 {lab=rowoff_n[5]}
N 6610 -4960 6810 -4960 {lab=rowoff_n[5]}
N 6600 -4930 6610 -4940 {lab=row_n[5]}
N 6610 -4940 6810 -4940 {lab=row_n[5]}
N 6810 -4940 6820 -4930 {lab=row_n[5]}
N 6810 -4960 6820 -4950 {lab=rowoff_n[5]}
N 6600 -4910 6610 -4920 {lab=rowon_n[5]}
N 6610 -4920 6810 -4920 {lab=rowon_n[5]}
N 6600 -4890 6610 -4900 {lab=#net9}
N 6610 -4900 6810 -4900 {lab=#net9}
N 6810 -4900 6820 -4890 {lab=#net9}
N 6600 -4870 6610 -4880 {lab=#net10}
N 6610 -4880 6810 -4880 {lab=#net10}
N 6810 -4880 6820 -4870 {lab=#net10}
N 6810 -4920 6820 -4910 {lab=rowon_n[5]}
N 1850 -5120 1850 -5110 {
lab=VSS}
N 2170 -5120 2170 -5110 {
lab=VSS}
N 2500 -5120 2500 -5110 {
lab=VSS}
N 2850 -5120 2850 -5110 {
lab=VSS}
N 3200 -5120 3200 -5110 {
lab=VSS}
N 3550 -5120 3550 -5110 {
lab=VSS}
N 3890 -5120 3890 -5110 {
lab=VSS}
N 4240 -5120 4240 -5110 {
lab=VSS}
N 4600 -5120 4600 -5110 {
lab=VSS}
N 4930 -5120 4930 -5110 {
lab=VSS}
N 5260 -5120 5260 -5110 {
lab=VSS}
N 5610 -5120 5610 -5110 {
lab=VSS}
N 5960 -5120 5960 -5110 {
lab=VSS}
N 6300 -5120 6300 -5110 {
lab=VSS}
N 6640 -5120 6640 -5110 {
lab=VSS}
N 6660 -5360 6660 -5340 {
lab=vcm}
N 6640 -5350 6640 -5340 {
lab=VDD}
N 6700 -5360 6700 -5340 {
lab=ctop}
N 5980 -5360 5980 -5340 {
lab=vcm}
N 5960 -5350 5960 -5340 {
lab=VDD}
N 6020 -5360 6020 -5340 {
lab=ctop}
N 6320 -5360 6320 -5340 {
lab=vcm}
N 6300 -5350 6300 -5340 {
lab=VDD}
N 6360 -5360 6360 -5340 {
lab=ctop}
N 5630 -5360 5630 -5340 {
lab=vcm}
N 5610 -5350 5610 -5340 {
lab=VDD}
N 5670 -5360 5670 -5340 {
lab=ctop}
N 5280 -5360 5280 -5340 {
lab=vcm}
N 5260 -5350 5260 -5340 {
lab=VDD}
N 5320 -5360 5320 -5340 {
lab=ctop}
N 4950 -5360 4950 -5340 {
lab=vcm}
N 4930 -5350 4930 -5340 {
lab=VDD}
N 4990 -5360 4990 -5340 {
lab=ctop}
N 4620 -5360 4620 -5340 {
lab=vcm}
N 4600 -5350 4600 -5340 {
lab=VDD}
N 4660 -5360 4660 -5340 {
lab=ctop}
N 4260 -5360 4260 -5340 {
lab=vcm}
N 4240 -5350 4240 -5340 {
lab=VDD}
N 4300 -5360 4300 -5340 {
lab=ctop}
N 3910 -5360 3910 -5340 {
lab=vcm}
N 3890 -5350 3890 -5340 {
lab=VDD}
N 3950 -5360 3950 -5340 {
lab=ctop}
N 3570 -5360 3570 -5340 {
lab=vcm}
N 3550 -5350 3550 -5340 {
lab=VDD}
N 3610 -5360 3610 -5340 {
lab=ctop}
N 3220 -5360 3220 -5340 {
lab=vcm}
N 3200 -5350 3200 -5340 {
lab=VDD}
N 3260 -5360 3260 -5340 {
lab=ctop}
N 2870 -5360 2870 -5340 {
lab=vcm}
N 2850 -5350 2850 -5340 {
lab=VDD}
N 2910 -5360 2910 -5340 {
lab=ctop}
N 2520 -5360 2520 -5340 {
lab=vcm}
N 2500 -5350 2500 -5340 {
lab=VDD}
N 2560 -5360 2560 -5340 {
lab=ctop}
N 2190 -5360 2190 -5340 {
lab=vcm}
N 2170 -5350 2170 -5340 {
lab=VDD}
N 2230 -5360 2230 -5340 {
lab=ctop}
N 1870 -5360 1870 -5340 {
lab=vcm}
N 1850 -5350 1850 -5340 {
lab=VDD}
N 1910 -5360 1910 -5340 {
lab=ctop}
N 1790 -5200 1810 -5200 {
lab=sample_n}
N 1790 -5220 1810 -5220 {
lab=sample}
N 1790 -5240 1810 -5240 {
lab=rowon_n[6]}
N 1790 -5260 1810 -5260 {
lab=row_n[6]}
N 1790 -5280 1810 -5280 {
lab=rowoff_n[6]}
N 2030 -5220 2130 -5220 {lab=#net11}
N 2030 -5200 2130 -5200 {lab=#net12}
N 1810 -5280 1820 -5290 {lab=rowoff_n[6]}
N 1820 -5290 2040 -5290 {lab=rowoff_n[6]}
N 2040 -5290 2050 -5280 {lab=rowoff_n[6]}
N 2050 -5280 2130 -5280 {lab=rowoff_n[6]}
N 1810 -5260 1820 -5270 {lab=row_n[6]}
N 1820 -5270 2040 -5270 {lab=row_n[6]}
N 2040 -5270 2050 -5260 {lab=row_n[6]}
N 2050 -5260 2130 -5260 {lab=row_n[6]}
N 1810 -5240 1820 -5250 {lab=rowon_n[6]}
N 1820 -5250 2040 -5250 {lab=rowon_n[6]}
N 2040 -5250 2050 -5240 {lab=rowon_n[6]}
N 2050 -5240 2130 -5240 {lab=rowon_n[6]}
N 2130 -5280 2140 -5290 {lab=rowoff_n[6]}
N 2130 -5260 2140 -5270 {lab=row_n[6]}
N 2140 -5270 2340 -5270 {lab=row_n[6]}
N 2340 -5270 2350 -5260 {lab=row_n[6]}
N 2350 -5260 2460 -5260 {lab=row_n[6]}
N 2140 -5290 2340 -5290 {lab=rowoff_n[6]}
N 2340 -5290 2350 -5280 {lab=rowoff_n[6]}
N 2350 -5280 2460 -5280 {lab=rowoff_n[6]}
N 2130 -5240 2140 -5250 {lab=rowon_n[6]}
N 2140 -5250 2340 -5250 {lab=rowon_n[6]}
N 2340 -5250 2350 -5240 {lab=rowon_n[6]}
N 2350 -5240 2460 -5240 {lab=rowon_n[6]}
N 2130 -5220 2140 -5230 {lab=#net11}
N 2140 -5230 2340 -5230 {lab=#net11}
N 2340 -5230 2350 -5220 {lab=#net11}
N 2350 -5220 2460 -5220 {lab=#net11}
N 2130 -5200 2140 -5210 {lab=#net12}
N 2140 -5210 2340 -5210 {lab=#net12}
N 2340 -5210 2350 -5200 {lab=#net12}
N 2350 -5200 2460 -5200 {lab=#net12}
N 2460 -5260 2470 -5270 {lab=row_n[6]}
N 2470 -5270 2670 -5270 {lab=row_n[6]}
N 2670 -5270 2680 -5260 {lab=row_n[6]}
N 2680 -5260 2810 -5260 {lab=row_n[6]}
N 2460 -5240 2470 -5250 {lab=rowon_n[6]}
N 2470 -5250 2670 -5250 {lab=rowon_n[6]}
N 2670 -5250 2680 -5240 {lab=rowon_n[6]}
N 2680 -5240 2810 -5240 {lab=rowon_n[6]}
N 2460 -5220 2470 -5230 {lab=#net11}
N 2470 -5230 2670 -5230 {lab=#net11}
N 2670 -5230 2680 -5220 {lab=#net11}
N 2680 -5220 2810 -5220 {lab=#net11}
N 2460 -5200 2480 -5210 {lab=#net12}
N 2480 -5210 2670 -5210 {lab=#net12}
N 2670 -5210 2680 -5200 {lab=#net12}
N 2680 -5200 2810 -5200 {lab=#net12}
N 2460 -5280 2470 -5290 {lab=rowoff_n[6]}
N 2470 -5290 2670 -5290 {lab=rowoff_n[6]}
N 2670 -5290 2680 -5280 {lab=rowoff_n[6]}
N 2680 -5280 2810 -5280 {lab=rowoff_n[6]}
N 2810 -5280 2820 -5290 {lab=rowoff_n[6]}
N 2820 -5290 3020 -5290 {lab=rowoff_n[6]}
N 3020 -5290 3030 -5280 {lab=rowoff_n[6]}
N 3030 -5280 3160 -5280 {lab=rowoff_n[6]}
N 2810 -5260 2820 -5270 {lab=row_n[6]}
N 2820 -5270 3020 -5270 {lab=row_n[6]}
N 3020 -5270 3030 -5260 {lab=row_n[6]}
N 3030 -5260 3160 -5260 {lab=row_n[6]}
N 2810 -5240 2820 -5250 {lab=rowon_n[6]}
N 2820 -5250 3020 -5250 {lab=rowon_n[6]}
N 3020 -5250 3030 -5240 {lab=rowon_n[6]}
N 3030 -5240 3160 -5240 {lab=rowon_n[6]}
N 2810 -5220 2820 -5230 {lab=#net11}
N 2820 -5230 3020 -5230 {lab=#net11}
N 3020 -5230 3030 -5220 {lab=#net11}
N 3030 -5220 3160 -5220 {lab=#net11}
N 2810 -5200 2820 -5210 {lab=#net12}
N 2820 -5210 3020 -5210 {lab=#net12}
N 3020 -5210 3030 -5200 {lab=#net12}
N 3030 -5200 3160 -5200 {lab=#net12}
N 3160 -5280 3170 -5290 {lab=rowoff_n[6]}
N 3170 -5290 3370 -5290 {lab=rowoff_n[6]}
N 3370 -5290 3380 -5280 {lab=rowoff_n[6]}
N 3380 -5280 3510 -5280 {lab=rowoff_n[6]}
N 3160 -5260 3170 -5270 {lab=row_n[6]}
N 3170 -5270 3370 -5270 {lab=row_n[6]}
N 3370 -5270 3380 -5260 {lab=row_n[6]}
N 3380 -5260 3510 -5260 {lab=row_n[6]}
N 3160 -5240 3170 -5250 {lab=rowon_n[6]}
N 3170 -5250 3370 -5250 {lab=rowon_n[6]}
N 3370 -5250 3380 -5240 {lab=rowon_n[6]}
N 3380 -5240 3510 -5240 {lab=rowon_n[6]}
N 3370 -5230 3380 -5220 {lab=#net11}
N 3380 -5220 3510 -5220 {lab=#net11}
N 3160 -5200 3170 -5210 {lab=#net12}
N 3170 -5210 3370 -5210 {lab=#net12}
N 3370 -5210 3380 -5200 {lab=#net12}
N 3380 -5200 3510 -5200 {lab=#net12}
N 3160 -5220 3170 -5230 {lab=#net11}
N 3170 -5230 3370 -5230 {lab=#net11}
N 3510 -5280 3520 -5290 {lab=rowoff_n[6]}
N 3520 -5290 3720 -5290 {lab=rowoff_n[6]}
N 3720 -5290 3730 -5280 {lab=rowoff_n[6]}
N 3730 -5280 3850 -5280 {lab=rowoff_n[6]}
N 3510 -5260 3520 -5270 {lab=row_n[6]}
N 3520 -5270 3720 -5270 {lab=row_n[6]}
N 3720 -5270 3730 -5260 {lab=row_n[6]}
N 3730 -5260 3850 -5260 {lab=row_n[6]}
N 3510 -5240 3520 -5250 {lab=rowon_n[6]}
N 3520 -5250 3720 -5250 {lab=rowon_n[6]}
N 3720 -5250 3730 -5240 {lab=rowon_n[6]}
N 3730 -5240 3850 -5240 {lab=rowon_n[6]}
N 3510 -5220 3520 -5230 {lab=#net11}
N 3520 -5230 3720 -5230 {lab=#net11}
N 3720 -5230 3730 -5220 {lab=#net11}
N 3730 -5220 3850 -5220 {lab=#net11}
N 3510 -5200 3520 -5210 {lab=#net12}
N 3520 -5210 3720 -5210 {lab=#net12}
N 3720 -5210 3730 -5200 {lab=#net12}
N 3730 -5200 3850 -5200 {lab=#net12}
N 3850 -5280 3860 -5290 {lab=rowoff_n[6]}
N 3860 -5290 4060 -5290 {lab=rowoff_n[6]}
N 4060 -5290 4070 -5280 {lab=rowoff_n[6]}
N 4070 -5280 4200 -5280 {lab=rowoff_n[6]}
N 3850 -5260 3860 -5270 {lab=row_n[6]}
N 3860 -5270 4060 -5270 {lab=row_n[6]}
N 4060 -5270 4070 -5260 {lab=row_n[6]}
N 4070 -5260 4200 -5260 {lab=row_n[6]}
N 3850 -5240 3860 -5250 {lab=rowon_n[6]}
N 3860 -5250 4060 -5250 {lab=rowon_n[6]}
N 4060 -5250 4070 -5240 {lab=rowon_n[6]}
N 4070 -5240 4200 -5240 {lab=rowon_n[6]}
N 3850 -5220 3860 -5230 {lab=#net11}
N 3860 -5230 4060 -5230 {lab=#net11}
N 3850 -5200 3860 -5210 {lab=#net12}
N 3860 -5210 4060 -5210 {lab=#net12}
N 4060 -5210 4070 -5200 {lab=#net12}
N 4070 -5200 4200 -5200 {lab=#net12}
N 4060 -5230 4070 -5220 {lab=#net11}
N 4070 -5220 4200 -5220 {lab=#net11}
N 4200 -5280 4210 -5290 {lab=rowoff_n[6]}
N 4210 -5290 4410 -5290 {lab=rowoff_n[6]}
N 4410 -5290 4420 -5280 {lab=rowoff_n[6]}
N 4420 -5280 4560 -5280 {lab=rowoff_n[6]}
N 4200 -5260 4210 -5270 {lab=row_n[6]}
N 4210 -5270 4410 -5270 {lab=row_n[6]}
N 4410 -5270 4420 -5260 {lab=row_n[6]}
N 4420 -5260 4560 -5260 {lab=row_n[6]}
N 4200 -5240 4210 -5250 {lab=rowon_n[6]}
N 4210 -5250 4410 -5250 {lab=rowon_n[6]}
N 4410 -5250 4420 -5240 {lab=rowon_n[6]}
N 4420 -5240 4560 -5240 {lab=rowon_n[6]}
N 4200 -5220 4210 -5230 {lab=#net11}
N 4210 -5230 4410 -5230 {lab=#net11}
N 4410 -5230 4420 -5220 {lab=#net11}
N 4420 -5220 4560 -5220 {lab=#net11}
N 4200 -5200 4210 -5210 {lab=#net12}
N 4210 -5210 4410 -5210 {lab=#net12}
N 4410 -5210 4420 -5200 {lab=#net12}
N 4420 -5200 4560 -5200 {lab=#net12}
N 4560 -5280 4570 -5290 {lab=rowoff_n[6]}
N 4570 -5290 4770 -5290 {lab=rowoff_n[6]}
N 4770 -5290 4780 -5280 {lab=rowoff_n[6]}
N 4780 -5280 4890 -5280 {lab=rowoff_n[6]}
N 4560 -5260 4570 -5270 {lab=row_n[6]}
N 4570 -5270 4770 -5270 {lab=row_n[6]}
N 4770 -5270 4780 -5260 {lab=row_n[6]}
N 4780 -5260 4890 -5260 {lab=row_n[6]}
N 4560 -5240 4570 -5250 {lab=rowon_n[6]}
N 4570 -5250 4770 -5250 {lab=rowon_n[6]}
N 4770 -5250 4780 -5240 {lab=rowon_n[6]}
N 4780 -5240 4890 -5240 {lab=rowon_n[6]}
N 4560 -5220 4570 -5230 {lab=#net11}
N 4570 -5230 4770 -5230 {lab=#net11}
N 4770 -5230 4780 -5220 {lab=#net11}
N 4780 -5220 4890 -5220 {lab=#net11}
N 4560 -5200 4570 -5210 {lab=#net12}
N 4570 -5210 4770 -5210 {lab=#net12}
N 4770 -5210 4780 -5200 {lab=#net12}
N 4780 -5200 4890 -5200 {lab=#net12}
N 4890 -5280 4900 -5290 {lab=rowoff_n[6]}
N 4900 -5290 5100 -5290 {lab=rowoff_n[6]}
N 5100 -5290 5110 -5280 {lab=rowoff_n[6]}
N 5110 -5280 5220 -5280 {lab=rowoff_n[6]}
N 4890 -5260 4900 -5270 {lab=row_n[6]}
N 4900 -5270 5100 -5270 {lab=row_n[6]}
N 5100 -5270 5110 -5260 {lab=row_n[6]}
N 5110 -5260 5220 -5260 {lab=row_n[6]}
N 4890 -5240 4900 -5250 {lab=rowon_n[6]}
N 4900 -5250 5100 -5250 {lab=rowon_n[6]}
N 5100 -5250 5110 -5240 {lab=rowon_n[6]}
N 5110 -5240 5220 -5240 {lab=rowon_n[6]}
N 4890 -5220 4900 -5230 {lab=#net11}
N 4900 -5230 5100 -5230 {lab=#net11}
N 5100 -5230 5110 -5220 {lab=#net11}
N 5110 -5220 5220 -5220 {lab=#net11}
N 4890 -5200 4900 -5210 {lab=#net12}
N 4900 -5210 5100 -5210 {lab=#net12}
N 5100 -5210 5120 -5200 {lab=#net12}
N 5120 -5200 5220 -5200 {lab=#net12}
N 5220 -5280 5230 -5290 {lab=rowoff_n[6]}
N 5230 -5290 5430 -5290 {lab=rowoff_n[6]}
N 5430 -5290 5440 -5280 {lab=rowoff_n[6]}
N 5440 -5280 5570 -5280 {lab=rowoff_n[6]}
N 5220 -5260 5230 -5270 {lab=row_n[6]}
N 5230 -5270 5430 -5270 {lab=row_n[6]}
N 5430 -5270 5440 -5260 {lab=row_n[6]}
N 5440 -5260 5570 -5260 {lab=row_n[6]}
N 5220 -5240 5230 -5250 {lab=rowon_n[6]}
N 5230 -5250 5430 -5250 {lab=rowon_n[6]}
N 5430 -5250 5440 -5240 {lab=rowon_n[6]}
N 5440 -5240 5570 -5240 {lab=rowon_n[6]}
N 5220 -5220 5230 -5230 {lab=#net11}
N 5230 -5230 5430 -5230 {lab=#net11}
N 5430 -5230 5440 -5220 {lab=#net11}
N 5440 -5220 5570 -5220 {lab=#net11}
N 5220 -5200 5230 -5210 {lab=#net12}
N 5230 -5210 5430 -5210 {lab=#net12}
N 5430 -5210 5440 -5200 {lab=#net12}
N 5440 -5200 5570 -5200 {lab=#net12}
N 5570 -5280 5580 -5290 {lab=rowoff_n[6]}
N 5580 -5290 5780 -5290 {lab=rowoff_n[6]}
N 5780 -5290 5790 -5280 {lab=rowoff_n[6]}
N 5790 -5280 5920 -5280 {lab=rowoff_n[6]}
N 5570 -5260 5580 -5270 {lab=row_n[6]}
N 5580 -5270 5780 -5270 {lab=row_n[6]}
N 5570 -5240 5580 -5250 {lab=rowon_n[6]}
N 5580 -5250 5780 -5250 {lab=rowon_n[6]}
N 5780 -5250 5790 -5240 {lab=rowon_n[6]}
N 5790 -5240 5920 -5240 {lab=rowon_n[6]}
N 5780 -5270 5790 -5260 {lab=row_n[6]}
N 5790 -5260 5920 -5260 {lab=row_n[6]}
N 5570 -5220 5580 -5230 {lab=#net11}
N 5580 -5230 5780 -5230 {lab=#net11}
N 5780 -5230 5790 -5220 {lab=#net11}
N 5790 -5220 5920 -5220 {lab=#net11}
N 5570 -5200 5580 -5210 {lab=#net12}
N 5580 -5210 5780 -5210 {lab=#net12}
N 5780 -5210 5790 -5200 {lab=#net12}
N 5790 -5200 5920 -5200 {lab=#net12}
N 5920 -5280 5930 -5290 {lab=rowoff_n[6]}
N 5930 -5290 6130 -5290 {lab=rowoff_n[6]}
N 6130 -5290 6140 -5280 {lab=rowoff_n[6]}
N 6140 -5280 6260 -5280 {lab=rowoff_n[6]}
N 5920 -5260 5930 -5270 {lab=row_n[6]}
N 5930 -5270 6130 -5270 {lab=row_n[6]}
N 6130 -5270 6140 -5260 {lab=row_n[6]}
N 6140 -5260 6260 -5260 {lab=row_n[6]}
N 5920 -5240 5930 -5250 {lab=rowon_n[6]}
N 5930 -5250 6130 -5250 {lab=rowon_n[6]}
N 6130 -5250 6140 -5240 {lab=rowon_n[6]}
N 6140 -5240 6260 -5240 {lab=rowon_n[6]}
N 5920 -5220 5930 -5230 {lab=#net11}
N 5930 -5230 6130 -5230 {lab=#net11}
N 6130 -5230 6140 -5220 {lab=#net11}
N 6140 -5220 6260 -5220 {lab=#net11}
N 5920 -5200 5930 -5210 {lab=#net12}
N 5930 -5210 6130 -5210 {lab=#net12}
N 6130 -5210 6140 -5200 {lab=#net12}
N 6140 -5200 6260 -5200 {lab=#net12}
N 6260 -5280 6270 -5290 {lab=rowoff_n[6]}
N 6270 -5290 6470 -5290 {lab=rowoff_n[6]}
N 6470 -5290 6480 -5280 {lab=rowoff_n[6]}
N 6480 -5280 6600 -5280 {lab=rowoff_n[6]}
N 6260 -5260 6270 -5270 {lab=row_n[6]}
N 6270 -5270 6470 -5270 {lab=row_n[6]}
N 6470 -5270 6480 -5260 {lab=row_n[6]}
N 6480 -5260 6600 -5260 {lab=row_n[6]}
N 6260 -5240 6270 -5250 {lab=rowon_n[6]}
N 6270 -5250 6470 -5250 {lab=rowon_n[6]}
N 6470 -5250 6480 -5240 {lab=rowon_n[6]}
N 6480 -5240 6600 -5240 {lab=rowon_n[6]}
N 6260 -5220 6270 -5230 {lab=#net11}
N 6270 -5230 6470 -5230 {lab=#net11}
N 6470 -5230 6480 -5220 {lab=#net11}
N 6480 -5220 6600 -5220 {lab=#net11}
N 6260 -5200 6270 -5210 {lab=#net12}
N 6270 -5210 6470 -5210 {lab=#net12}
N 6470 -5210 6490 -5200 {lab=#net12}
N 6490 -5200 6600 -5200 {lab=#net12}
N 6600 -5280 6610 -5290 {lab=rowoff_n[6]}
N 6610 -5290 6810 -5290 {lab=rowoff_n[6]}
N 6600 -5260 6610 -5270 {lab=row_n[6]}
N 6610 -5270 6810 -5270 {lab=row_n[6]}
N 6810 -5270 6820 -5260 {lab=row_n[6]}
N 6810 -5290 6820 -5280 {lab=rowoff_n[6]}
N 6600 -5240 6610 -5250 {lab=rowon_n[6]}
N 6610 -5250 6810 -5250 {lab=rowon_n[6]}
N 6600 -5220 6610 -5230 {lab=#net11}
N 6610 -5230 6810 -5230 {lab=#net11}
N 6810 -5230 6820 -5220 {lab=#net11}
N 6600 -5200 6610 -5210 {lab=#net12}
N 6610 -5210 6810 -5210 {lab=#net12}
N 6810 -5210 6820 -5200 {lab=#net12}
N 6810 -5250 6820 -5240 {lab=rowon_n[6]}
N 1930 -4790 1940 -4800 {lab=VDD}
N 1940 -5050 1940 -4800 {lab=VDD}
N 1930 -5060 1940 -5050 {lab=VDD}
N 1930 -5120 1930 -5060 {lab=VDD}
N 1950 -5120 1950 -5060 {lab=VSS}
N 1950 -5060 1960 -5050 {lab=VSS}
N 1960 -5050 1960 -4800 {lab=VSS}
N 1950 -4790 1960 -4800 {lab=VSS}
N 2260 -5050 2260 -4800 {lab=col_n[0]}
N 2250 -5060 2260 -5050 {lab=col_n[0]}
N 2250 -5120 2250 -5060 {lab=col_n[0]}
N 2270 -5120 2270 -5060 {lab=col[0]}
N 2270 -5060 2280 -5050 {lab=col[0]}
N 2280 -5050 2280 -4800 {lab=col[0]}
N 2590 -5050 2590 -4800 {lab=col_n[1]}
N 2580 -5060 2590 -5050 {lab=col_n[1]}
N 2580 -5120 2580 -5060 {lab=col_n[1]}
N 2600 -5120 2600 -5060 {lab=col[1]}
N 2600 -5060 2610 -5050 {lab=col[1]}
N 2610 -5050 2610 -4800 {lab=col[1]}
N 2940 -5050 2940 -4800 {lab=col_n[2]}
N 2930 -5060 2940 -5050 {lab=col_n[2]}
N 2930 -5120 2930 -5060 {lab=col_n[2]}
N 2950 -5120 2950 -5060 {lab=col[2]}
N 2950 -5060 2960 -5050 {lab=col[2]}
N 2960 -5050 2960 -4800 {lab=col[2]}
N 3290 -5050 3290 -4800 {lab=col_n[3]}
N 3280 -5060 3290 -5050 {lab=col_n[3]}
N 3280 -5120 3280 -5060 {lab=col_n[3]}
N 3300 -5120 3300 -5060 {lab=col[3]}
N 3300 -5060 3310 -5050 {lab=col[3]}
N 3310 -5050 3310 -4800 {lab=col[3]}
N 3640 -5050 3640 -4800 {lab=col_n[4]}
N 3630 -5060 3640 -5050 {lab=col_n[4]}
N 3630 -5120 3630 -5060 {lab=col_n[4]}
N 3650 -5120 3650 -5060 {lab=col[4]}
N 3650 -5060 3660 -5050 {lab=col[4]}
N 3660 -5050 3660 -4800 {lab=col[4]}
N 3980 -5050 3980 -4800 {lab=col_n[5]}
N 3970 -5060 3980 -5050 {lab=col_n[5]}
N 3970 -5120 3970 -5060 {lab=col_n[5]}
N 3990 -5120 3990 -5060 {lab=col[5]}
N 3990 -5060 4000 -5050 {lab=col[5]}
N 4000 -5050 4000 -4800 {lab=col[5]}
N 4330 -5050 4330 -4800 {lab=col_n[6]}
N 4320 -5060 4330 -5050 {lab=col_n[6]}
N 4320 -5120 4320 -5060 {lab=col_n[6]}
N 4340 -5120 4340 -5060 {lab=col[6]}
N 4340 -5060 4350 -5050 {lab=col[6]}
N 4350 -5050 4350 -4800 {lab=col[6]}
N 4690 -5050 4690 -4800 {lab=col_n[7]}
N 4680 -5060 4690 -5050 {lab=col_n[7]}
N 4680 -5120 4680 -5060 {lab=col_n[7]}
N 4700 -5120 4700 -5060 {lab=col[7]}
N 4700 -5060 4710 -5050 {lab=col[7]}
N 4710 -5050 4710 -4800 {lab=col[7]}
N 5020 -5050 5020 -4800 {lab=col_n[8]}
N 5010 -5060 5020 -5050 {lab=col_n[8]}
N 5010 -5120 5010 -5060 {lab=col_n[8]}
N 5030 -5120 5030 -5060 {lab=col[8]}
N 5030 -5060 5040 -5050 {lab=col[8]}
N 5040 -5050 5040 -4800 {lab=col[8]}
N 5350 -5050 5350 -4800 {lab=col_n[9]}
N 5340 -5060 5350 -5050 {lab=col_n[9]}
N 5340 -5120 5340 -5060 {lab=col_n[9]}
N 5360 -5120 5360 -5060 {lab=col[9]}
N 5360 -5060 5370 -5050 {lab=col[9]}
N 5370 -5050 5370 -4800 {lab=col[9]}
N 5700 -5050 5700 -4800 {lab=col_n[10]}
N 5690 -5060 5700 -5050 {lab=col_n[10]}
N 5690 -5120 5690 -5060 {lab=col_n[10]}
N 5710 -5120 5710 -5060 {lab=col[10]}
N 5710 -5060 5720 -5050 {lab=col[10]}
N 5720 -5050 5720 -4800 {lab=col[10]}
N 6050 -5050 6050 -4800 {lab=col_n[11]}
N 6040 -5060 6050 -5050 {lab=col_n[11]}
N 6040 -5120 6040 -5060 {lab=col_n[11]}
N 6060 -5120 6060 -5060 {lab=col[11]}
N 6060 -5060 6070 -5050 {lab=col[11]}
N 6070 -5050 6070 -4800 {lab=col[11]}
N 6390 -5050 6390 -4800 {lab=col_n[12]}
N 6380 -5060 6390 -5050 {lab=col_n[12]}
N 6380 -5120 6380 -5060 {lab=col_n[12]}
N 6400 -5120 6400 -5060 {lab=col[12]}
N 6400 -5060 6410 -5050 {lab=col[12]}
N 6410 -5050 6410 -4800 {lab=col[12]}
N 6730 -5050 6730 -4800 {lab=VDD}
N 6720 -5060 6730 -5050 {lab=VDD}
N 6720 -5120 6720 -5060 {lab=VDD}
N 6740 -5120 6740 -5060 {lab=VSS}
N 6740 -5060 6750 -5050 {lab=VSS}
N 6750 -5050 6750 -4800 {lab=VSS}
N 6740 -4790 6750 -4800 {lab=VSS}
N 6720 -4790 6730 -4800 {lab=VDD}
N 6380 -4790 6390 -4800 {lab=col_n[12]}
N 6400 -4790 6410 -4800 {lab=col[12]}
N 6040 -4790 6050 -4800 {lab=col_n[11]}
N 6060 -4790 6070 -4800 {lab=col[11]}
N 5690 -4790 5700 -4800 {lab=col_n[10]}
N 5710 -4790 5720 -4800 {lab=col[10]}
N 5360 -4790 5370 -4800 {lab=col[9]}
N 5340 -4790 5350 -4800 {lab=col_n[9]}
N 5030 -4790 5040 -4800 {lab=col[8]}
N 5010 -4790 5020 -4800 {lab=col_n[8]}
N 4680 -4790 4690 -4800 {lab=col_n[7]}
N 4700 -4790 4710 -4800 {lab=col[7]}
N 4320 -4790 4330 -4800 {lab=col_n[6]}
N 4340 -4790 4350 -4800 {lab=col[6]}
N 3990 -4790 4000 -4800 {lab=col[5]}
N 3970 -4790 3980 -4800 {lab=col_n[5]}
N 3650 -4790 3660 -4800 {lab=col[4]}
N 3630 -4790 3640 -4800 {lab=col_n[4]}
N 3300 -4790 3310 -4800 {lab=col[3]}
N 3280 -4790 3290 -4800 {lab=col_n[3]}
N 2950 -4790 2960 -4800 {lab=col[2]}
N 2930 -4790 2940 -4800 {lab=col_n[2]}
N 2600 -4790 2610 -4800 {lab=col[1]}
N 2580 -4790 2590 -4800 {lab=col_n[1]}
N 2250 -4790 2260 -4800 {lab=col_n[0]}
N 2270 -4790 2280 -4800 {lab=col[0]}
N 1930 -4790 1930 -4750 {lab=VDD}
N 1950 -4790 1950 -4750 {lab=VSS}
N 1850 -5440 1850 -5430 {
lab=VSS}
N 2170 -5440 2170 -5430 {
lab=VSS}
N 2500 -5440 2500 -5430 {
lab=VSS}
N 2850 -5440 2850 -5430 {
lab=VSS}
N 3200 -5440 3200 -5430 {
lab=VSS}
N 3550 -5440 3550 -5430 {
lab=VSS}
N 3890 -5440 3890 -5430 {
lab=VSS}
N 4240 -5440 4240 -5430 {
lab=VSS}
N 4600 -5440 4600 -5430 {
lab=VSS}
N 4930 -5440 4930 -5430 {
lab=VSS}
N 5260 -5440 5260 -5430 {
lab=VSS}
N 5610 -5440 5610 -5430 {
lab=VSS}
N 5960 -5440 5960 -5430 {
lab=VSS}
N 6300 -5440 6300 -5430 {
lab=VSS}
N 6640 -5440 6640 -5430 {
lab=VSS}
N 6660 -5680 6660 -5660 {
lab=vcm}
N 6640 -5670 6640 -5660 {
lab=VDD}
N 6700 -5680 6700 -5660 {
lab=ctop}
N 5980 -5680 5980 -5660 {
lab=vcm}
N 5960 -5670 5960 -5660 {
lab=VDD}
N 6020 -5680 6020 -5660 {
lab=ctop}
N 6320 -5680 6320 -5660 {
lab=vcm}
N 6300 -5670 6300 -5660 {
lab=VDD}
N 6360 -5680 6360 -5660 {
lab=ctop}
N 5630 -5680 5630 -5660 {
lab=vcm}
N 5610 -5670 5610 -5660 {
lab=VDD}
N 5670 -5680 5670 -5660 {
lab=ctop}
N 5280 -5680 5280 -5660 {
lab=vcm}
N 5260 -5670 5260 -5660 {
lab=VDD}
N 5320 -5680 5320 -5660 {
lab=ctop}
N 4950 -5680 4950 -5660 {
lab=vcm}
N 4930 -5670 4930 -5660 {
lab=VDD}
N 4990 -5680 4990 -5660 {
lab=ctop}
N 4620 -5680 4620 -5660 {
lab=vcm}
N 4600 -5670 4600 -5660 {
lab=VDD}
N 4660 -5680 4660 -5660 {
lab=ctop}
N 4260 -5680 4260 -5660 {
lab=vcm}
N 4240 -5670 4240 -5660 {
lab=VDD}
N 4300 -5680 4300 -5660 {
lab=ctop}
N 3910 -5680 3910 -5660 {
lab=vcm}
N 3890 -5670 3890 -5660 {
lab=VDD}
N 3950 -5680 3950 -5660 {
lab=ctop}
N 3570 -5680 3570 -5660 {
lab=vcm}
N 3550 -5670 3550 -5660 {
lab=VDD}
N 3610 -5680 3610 -5660 {
lab=ctop}
N 3220 -5680 3220 -5660 {
lab=vcm}
N 3200 -5670 3200 -5660 {
lab=VDD}
N 3260 -5680 3260 -5660 {
lab=ctop}
N 2870 -5680 2870 -5660 {
lab=vcm}
N 2850 -5670 2850 -5660 {
lab=VDD}
N 2910 -5680 2910 -5660 {
lab=ctop}
N 2520 -5680 2520 -5660 {
lab=vcm}
N 2500 -5670 2500 -5660 {
lab=VDD}
N 2560 -5680 2560 -5660 {
lab=ctop}
N 2190 -5680 2190 -5660 {
lab=vcm}
N 2170 -5670 2170 -5660 {
lab=VDD}
N 2230 -5680 2230 -5660 {
lab=ctop}
N 1870 -5680 1870 -5660 {
lab=vcm}
N 1850 -5670 1850 -5660 {
lab=VDD}
N 1910 -5680 1910 -5660 {
lab=ctop}
N 1790 -5520 1810 -5520 {
lab=sample_n}
N 1790 -5540 1810 -5540 {
lab=sample}
N 1790 -5560 1810 -5560 {
lab=rowon_n[7]}
N 1790 -5580 1810 -5580 {
lab=row_n[7]}
N 1790 -5600 1810 -5600 {
lab=rowoff_n[7]}
N 2030 -5540 2130 -5540 {lab=#net13}
N 2030 -5520 2130 -5520 {lab=#net14}
N 1810 -5600 1820 -5610 {lab=rowoff_n[7]}
N 1820 -5610 2040 -5610 {lab=rowoff_n[7]}
N 2040 -5610 2050 -5600 {lab=rowoff_n[7]}
N 2050 -5600 2130 -5600 {lab=rowoff_n[7]}
N 1810 -5580 1820 -5590 {lab=row_n[7]}
N 1820 -5590 2040 -5590 {lab=row_n[7]}
N 2040 -5590 2050 -5580 {lab=row_n[7]}
N 2050 -5580 2130 -5580 {lab=row_n[7]}
N 1810 -5560 1820 -5570 {lab=rowon_n[7]}
N 1820 -5570 2040 -5570 {lab=rowon_n[7]}
N 2040 -5570 2050 -5560 {lab=rowon_n[7]}
N 2050 -5560 2130 -5560 {lab=rowon_n[7]}
N 2130 -5600 2140 -5610 {lab=rowoff_n[7]}
N 2130 -5580 2140 -5590 {lab=row_n[7]}
N 2140 -5590 2340 -5590 {lab=row_n[7]}
N 2340 -5590 2350 -5580 {lab=row_n[7]}
N 2350 -5580 2460 -5580 {lab=row_n[7]}
N 2140 -5610 2340 -5610 {lab=rowoff_n[7]}
N 2340 -5610 2350 -5600 {lab=rowoff_n[7]}
N 2350 -5600 2460 -5600 {lab=rowoff_n[7]}
N 2130 -5560 2140 -5570 {lab=rowon_n[7]}
N 2140 -5570 2340 -5570 {lab=rowon_n[7]}
N 2340 -5570 2350 -5560 {lab=rowon_n[7]}
N 2350 -5560 2460 -5560 {lab=rowon_n[7]}
N 2130 -5540 2140 -5550 {lab=#net13}
N 2140 -5550 2340 -5550 {lab=#net13}
N 2340 -5550 2350 -5540 {lab=#net13}
N 2350 -5540 2460 -5540 {lab=#net13}
N 2130 -5520 2140 -5530 {lab=#net14}
N 2140 -5530 2340 -5530 {lab=#net14}
N 2340 -5530 2350 -5520 {lab=#net14}
N 2350 -5520 2460 -5520 {lab=#net14}
N 2460 -5580 2470 -5590 {lab=row_n[7]}
N 2470 -5590 2670 -5590 {lab=row_n[7]}
N 2670 -5590 2680 -5580 {lab=row_n[7]}
N 2680 -5580 2810 -5580 {lab=row_n[7]}
N 2460 -5560 2470 -5570 {lab=rowon_n[7]}
N 2470 -5570 2670 -5570 {lab=rowon_n[7]}
N 2670 -5570 2680 -5560 {lab=rowon_n[7]}
N 2680 -5560 2810 -5560 {lab=rowon_n[7]}
N 2460 -5540 2470 -5550 {lab=#net13}
N 2470 -5550 2670 -5550 {lab=#net13}
N 2670 -5550 2680 -5540 {lab=#net13}
N 2680 -5540 2810 -5540 {lab=#net13}
N 2460 -5520 2480 -5530 {lab=#net14}
N 2480 -5530 2670 -5530 {lab=#net14}
N 2670 -5530 2680 -5520 {lab=#net14}
N 2680 -5520 2810 -5520 {lab=#net14}
N 2460 -5600 2470 -5610 {lab=rowoff_n[7]}
N 2470 -5610 2670 -5610 {lab=rowoff_n[7]}
N 2670 -5610 2680 -5600 {lab=rowoff_n[7]}
N 2680 -5600 2810 -5600 {lab=rowoff_n[7]}
N 2810 -5600 2820 -5610 {lab=rowoff_n[7]}
N 2820 -5610 3020 -5610 {lab=rowoff_n[7]}
N 3020 -5610 3030 -5600 {lab=rowoff_n[7]}
N 3030 -5600 3160 -5600 {lab=rowoff_n[7]}
N 2810 -5580 2820 -5590 {lab=row_n[7]}
N 2820 -5590 3020 -5590 {lab=row_n[7]}
N 3020 -5590 3030 -5580 {lab=row_n[7]}
N 3030 -5580 3160 -5580 {lab=row_n[7]}
N 2810 -5560 2820 -5570 {lab=rowon_n[7]}
N 2820 -5570 3020 -5570 {lab=rowon_n[7]}
N 3020 -5570 3030 -5560 {lab=rowon_n[7]}
N 3030 -5560 3160 -5560 {lab=rowon_n[7]}
N 2810 -5540 2820 -5550 {lab=#net13}
N 2820 -5550 3020 -5550 {lab=#net13}
N 3020 -5550 3030 -5540 {lab=#net13}
N 3030 -5540 3160 -5540 {lab=#net13}
N 2810 -5520 2820 -5530 {lab=#net14}
N 2820 -5530 3020 -5530 {lab=#net14}
N 3020 -5530 3030 -5520 {lab=#net14}
N 3030 -5520 3160 -5520 {lab=#net14}
N 3160 -5600 3170 -5610 {lab=rowoff_n[7]}
N 3170 -5610 3370 -5610 {lab=rowoff_n[7]}
N 3370 -5610 3380 -5600 {lab=rowoff_n[7]}
N 3380 -5600 3510 -5600 {lab=rowoff_n[7]}
N 3160 -5580 3170 -5590 {lab=row_n[7]}
N 3170 -5590 3370 -5590 {lab=row_n[7]}
N 3370 -5590 3380 -5580 {lab=row_n[7]}
N 3380 -5580 3510 -5580 {lab=row_n[7]}
N 3160 -5560 3170 -5570 {lab=rowon_n[7]}
N 3170 -5570 3370 -5570 {lab=rowon_n[7]}
N 3370 -5570 3380 -5560 {lab=rowon_n[7]}
N 3380 -5560 3510 -5560 {lab=rowon_n[7]}
N 3370 -5550 3380 -5540 {lab=#net13}
N 3380 -5540 3510 -5540 {lab=#net13}
N 3160 -5520 3170 -5530 {lab=#net14}
N 3170 -5530 3370 -5530 {lab=#net14}
N 3370 -5530 3380 -5520 {lab=#net14}
N 3380 -5520 3510 -5520 {lab=#net14}
N 3160 -5540 3170 -5550 {lab=#net13}
N 3170 -5550 3370 -5550 {lab=#net13}
N 3510 -5600 3520 -5610 {lab=rowoff_n[7]}
N 3520 -5610 3720 -5610 {lab=rowoff_n[7]}
N 3720 -5610 3730 -5600 {lab=rowoff_n[7]}
N 3730 -5600 3850 -5600 {lab=rowoff_n[7]}
N 3510 -5580 3520 -5590 {lab=row_n[7]}
N 3520 -5590 3720 -5590 {lab=row_n[7]}
N 3720 -5590 3730 -5580 {lab=row_n[7]}
N 3730 -5580 3850 -5580 {lab=row_n[7]}
N 3510 -5560 3520 -5570 {lab=rowon_n[7]}
N 3520 -5570 3720 -5570 {lab=rowon_n[7]}
N 3720 -5570 3730 -5560 {lab=rowon_n[7]}
N 3730 -5560 3850 -5560 {lab=rowon_n[7]}
N 3510 -5540 3520 -5550 {lab=#net13}
N 3520 -5550 3720 -5550 {lab=#net13}
N 3720 -5550 3730 -5540 {lab=#net13}
N 3730 -5540 3850 -5540 {lab=#net13}
N 3510 -5520 3520 -5530 {lab=#net14}
N 3520 -5530 3720 -5530 {lab=#net14}
N 3720 -5530 3730 -5520 {lab=#net14}
N 3730 -5520 3850 -5520 {lab=#net14}
N 3850 -5600 3860 -5610 {lab=rowoff_n[7]}
N 3860 -5610 4060 -5610 {lab=rowoff_n[7]}
N 4060 -5610 4070 -5600 {lab=rowoff_n[7]}
N 4070 -5600 4200 -5600 {lab=rowoff_n[7]}
N 3850 -5580 3860 -5590 {lab=row_n[7]}
N 3860 -5590 4060 -5590 {lab=row_n[7]}
N 4060 -5590 4070 -5580 {lab=row_n[7]}
N 4070 -5580 4200 -5580 {lab=row_n[7]}
N 3850 -5560 3860 -5570 {lab=rowon_n[7]}
N 3860 -5570 4060 -5570 {lab=rowon_n[7]}
N 4060 -5570 4070 -5560 {lab=rowon_n[7]}
N 4070 -5560 4200 -5560 {lab=rowon_n[7]}
N 3850 -5540 3860 -5550 {lab=#net13}
N 3860 -5550 4060 -5550 {lab=#net13}
N 3850 -5520 3860 -5530 {lab=#net14}
N 3860 -5530 4060 -5530 {lab=#net14}
N 4060 -5530 4070 -5520 {lab=#net14}
N 4070 -5520 4200 -5520 {lab=#net14}
N 4060 -5550 4070 -5540 {lab=#net13}
N 4070 -5540 4200 -5540 {lab=#net13}
N 4200 -5600 4210 -5610 {lab=rowoff_n[7]}
N 4210 -5610 4410 -5610 {lab=rowoff_n[7]}
N 4410 -5610 4420 -5600 {lab=rowoff_n[7]}
N 4420 -5600 4560 -5600 {lab=rowoff_n[7]}
N 4200 -5580 4210 -5590 {lab=row_n[7]}
N 4210 -5590 4410 -5590 {lab=row_n[7]}
N 4410 -5590 4420 -5580 {lab=row_n[7]}
N 4420 -5580 4560 -5580 {lab=row_n[7]}
N 4200 -5560 4210 -5570 {lab=rowon_n[7]}
N 4210 -5570 4410 -5570 {lab=rowon_n[7]}
N 4410 -5570 4420 -5560 {lab=rowon_n[7]}
N 4420 -5560 4560 -5560 {lab=rowon_n[7]}
N 4200 -5540 4210 -5550 {lab=#net13}
N 4210 -5550 4410 -5550 {lab=#net13}
N 4410 -5550 4420 -5540 {lab=#net13}
N 4420 -5540 4560 -5540 {lab=#net13}
N 4200 -5520 4210 -5530 {lab=#net14}
N 4210 -5530 4410 -5530 {lab=#net14}
N 4410 -5530 4420 -5520 {lab=#net14}
N 4420 -5520 4560 -5520 {lab=#net14}
N 4560 -5600 4570 -5610 {lab=rowoff_n[7]}
N 4570 -5610 4770 -5610 {lab=rowoff_n[7]}
N 4770 -5610 4780 -5600 {lab=rowoff_n[7]}
N 4780 -5600 4890 -5600 {lab=rowoff_n[7]}
N 4560 -5580 4570 -5590 {lab=row_n[7]}
N 4570 -5590 4770 -5590 {lab=row_n[7]}
N 4770 -5590 4780 -5580 {lab=row_n[7]}
N 4780 -5580 4890 -5580 {lab=row_n[7]}
N 4560 -5560 4570 -5570 {lab=rowon_n[7]}
N 4570 -5570 4770 -5570 {lab=rowon_n[7]}
N 4770 -5570 4780 -5560 {lab=rowon_n[7]}
N 4780 -5560 4890 -5560 {lab=rowon_n[7]}
N 4560 -5540 4570 -5550 {lab=#net13}
N 4570 -5550 4770 -5550 {lab=#net13}
N 4770 -5550 4780 -5540 {lab=#net13}
N 4780 -5540 4890 -5540 {lab=#net13}
N 4560 -5520 4570 -5530 {lab=#net14}
N 4570 -5530 4770 -5530 {lab=#net14}
N 4770 -5530 4780 -5520 {lab=#net14}
N 4780 -5520 4890 -5520 {lab=#net14}
N 4890 -5600 4900 -5610 {lab=rowoff_n[7]}
N 4900 -5610 5100 -5610 {lab=rowoff_n[7]}
N 5100 -5610 5110 -5600 {lab=rowoff_n[7]}
N 5110 -5600 5220 -5600 {lab=rowoff_n[7]}
N 4890 -5580 4900 -5590 {lab=row_n[7]}
N 4900 -5590 5100 -5590 {lab=row_n[7]}
N 5100 -5590 5110 -5580 {lab=row_n[7]}
N 5110 -5580 5220 -5580 {lab=row_n[7]}
N 4890 -5560 4900 -5570 {lab=rowon_n[7]}
N 4900 -5570 5100 -5570 {lab=rowon_n[7]}
N 5100 -5570 5110 -5560 {lab=rowon_n[7]}
N 5110 -5560 5220 -5560 {lab=rowon_n[7]}
N 4890 -5540 4900 -5550 {lab=#net13}
N 4900 -5550 5100 -5550 {lab=#net13}
N 5100 -5550 5110 -5540 {lab=#net13}
N 5110 -5540 5220 -5540 {lab=#net13}
N 4890 -5520 4900 -5530 {lab=#net14}
N 4900 -5530 5100 -5530 {lab=#net14}
N 5100 -5530 5120 -5520 {lab=#net14}
N 5120 -5520 5220 -5520 {lab=#net14}
N 5220 -5600 5230 -5610 {lab=rowoff_n[7]}
N 5230 -5610 5430 -5610 {lab=rowoff_n[7]}
N 5430 -5610 5440 -5600 {lab=rowoff_n[7]}
N 5440 -5600 5570 -5600 {lab=rowoff_n[7]}
N 5220 -5580 5230 -5590 {lab=row_n[7]}
N 5230 -5590 5430 -5590 {lab=row_n[7]}
N 5430 -5590 5440 -5580 {lab=row_n[7]}
N 5440 -5580 5570 -5580 {lab=row_n[7]}
N 5220 -5560 5230 -5570 {lab=rowon_n[7]}
N 5230 -5570 5430 -5570 {lab=rowon_n[7]}
N 5430 -5570 5440 -5560 {lab=rowon_n[7]}
N 5440 -5560 5570 -5560 {lab=rowon_n[7]}
N 5220 -5540 5230 -5550 {lab=#net13}
N 5230 -5550 5430 -5550 {lab=#net13}
N 5430 -5550 5440 -5540 {lab=#net13}
N 5440 -5540 5570 -5540 {lab=#net13}
N 5220 -5520 5230 -5530 {lab=#net14}
N 5230 -5530 5430 -5530 {lab=#net14}
N 5430 -5530 5440 -5520 {lab=#net14}
N 5440 -5520 5570 -5520 {lab=#net14}
N 5570 -5600 5580 -5610 {lab=rowoff_n[7]}
N 5580 -5610 5780 -5610 {lab=rowoff_n[7]}
N 5780 -5610 5790 -5600 {lab=rowoff_n[7]}
N 5790 -5600 5920 -5600 {lab=rowoff_n[7]}
N 5570 -5580 5580 -5590 {lab=row_n[7]}
N 5580 -5590 5780 -5590 {lab=row_n[7]}
N 5570 -5560 5580 -5570 {lab=rowon_n[7]}
N 5580 -5570 5780 -5570 {lab=rowon_n[7]}
N 5780 -5570 5790 -5560 {lab=rowon_n[7]}
N 5790 -5560 5920 -5560 {lab=rowon_n[7]}
N 5780 -5590 5790 -5580 {lab=row_n[7]}
N 5790 -5580 5920 -5580 {lab=row_n[7]}
N 5570 -5540 5580 -5550 {lab=#net13}
N 5580 -5550 5780 -5550 {lab=#net13}
N 5780 -5550 5790 -5540 {lab=#net13}
N 5790 -5540 5920 -5540 {lab=#net13}
N 5570 -5520 5580 -5530 {lab=#net14}
N 5580 -5530 5780 -5530 {lab=#net14}
N 5780 -5530 5790 -5520 {lab=#net14}
N 5790 -5520 5920 -5520 {lab=#net14}
N 5920 -5600 5930 -5610 {lab=rowoff_n[7]}
N 5930 -5610 6130 -5610 {lab=rowoff_n[7]}
N 6130 -5610 6140 -5600 {lab=rowoff_n[7]}
N 6140 -5600 6260 -5600 {lab=rowoff_n[7]}
N 5920 -5580 5930 -5590 {lab=row_n[7]}
N 5930 -5590 6130 -5590 {lab=row_n[7]}
N 6130 -5590 6140 -5580 {lab=row_n[7]}
N 6140 -5580 6260 -5580 {lab=row_n[7]}
N 5920 -5560 5930 -5570 {lab=rowon_n[7]}
N 5930 -5570 6130 -5570 {lab=rowon_n[7]}
N 6130 -5570 6140 -5560 {lab=rowon_n[7]}
N 6140 -5560 6260 -5560 {lab=rowon_n[7]}
N 5920 -5540 5930 -5550 {lab=#net13}
N 5930 -5550 6130 -5550 {lab=#net13}
N 6130 -5550 6140 -5540 {lab=#net13}
N 6140 -5540 6260 -5540 {lab=#net13}
N 5920 -5520 5930 -5530 {lab=#net14}
N 5930 -5530 6130 -5530 {lab=#net14}
N 6130 -5530 6140 -5520 {lab=#net14}
N 6140 -5520 6260 -5520 {lab=#net14}
N 6260 -5600 6270 -5610 {lab=rowoff_n[7]}
N 6270 -5610 6470 -5610 {lab=rowoff_n[7]}
N 6470 -5610 6480 -5600 {lab=rowoff_n[7]}
N 6480 -5600 6600 -5600 {lab=rowoff_n[7]}
N 6260 -5580 6270 -5590 {lab=row_n[7]}
N 6270 -5590 6470 -5590 {lab=row_n[7]}
N 6470 -5590 6480 -5580 {lab=row_n[7]}
N 6480 -5580 6600 -5580 {lab=row_n[7]}
N 6260 -5560 6270 -5570 {lab=rowon_n[7]}
N 6270 -5570 6470 -5570 {lab=rowon_n[7]}
N 6470 -5570 6480 -5560 {lab=rowon_n[7]}
N 6480 -5560 6600 -5560 {lab=rowon_n[7]}
N 6260 -5540 6270 -5550 {lab=#net13}
N 6270 -5550 6470 -5550 {lab=#net13}
N 6470 -5550 6480 -5540 {lab=#net13}
N 6480 -5540 6600 -5540 {lab=#net13}
N 6260 -5520 6270 -5530 {lab=#net14}
N 6270 -5530 6470 -5530 {lab=#net14}
N 6470 -5530 6490 -5520 {lab=#net14}
N 6490 -5520 6600 -5520 {lab=#net14}
N 6600 -5600 6610 -5610 {lab=rowoff_n[7]}
N 6610 -5610 6810 -5610 {lab=rowoff_n[7]}
N 6600 -5580 6610 -5590 {lab=row_n[7]}
N 6610 -5590 6810 -5590 {lab=row_n[7]}
N 6810 -5590 6820 -5580 {lab=row_n[7]}
N 6810 -5610 6820 -5600 {lab=rowoff_n[7]}
N 6600 -5560 6610 -5570 {lab=rowon_n[7]}
N 6610 -5570 6810 -5570 {lab=rowon_n[7]}
N 6600 -5540 6610 -5550 {lab=#net13}
N 6610 -5550 6810 -5550 {lab=#net13}
N 6810 -5550 6820 -5540 {lab=#net13}
N 6600 -5520 6610 -5530 {lab=#net14}
N 6610 -5530 6810 -5530 {lab=#net14}
N 6810 -5530 6820 -5520 {lab=#net14}
N 6810 -5570 6820 -5560 {lab=rowon_n[7]}
N 1850 -5770 1850 -5760 {
lab=VSS}
N 2170 -5770 2170 -5760 {
lab=VSS}
N 2500 -5770 2500 -5760 {
lab=VSS}
N 2850 -5770 2850 -5760 {
lab=VSS}
N 3200 -5770 3200 -5760 {
lab=VSS}
N 3550 -5770 3550 -5760 {
lab=VSS}
N 3890 -5770 3890 -5760 {
lab=VSS}
N 4240 -5770 4240 -5760 {
lab=VSS}
N 4600 -5770 4600 -5760 {
lab=VSS}
N 4930 -5770 4930 -5760 {
lab=VSS}
N 5260 -5770 5260 -5760 {
lab=VSS}
N 5610 -5770 5610 -5760 {
lab=VSS}
N 5960 -5770 5960 -5760 {
lab=VSS}
N 6300 -5770 6300 -5760 {
lab=VSS}
N 6640 -5770 6640 -5760 {
lab=VSS}
N 6660 -6010 6660 -5990 {
lab=vcm}
N 6640 -6000 6640 -5990 {
lab=VDD}
N 6700 -6010 6700 -5990 {
lab=ctop}
N 5980 -6010 5980 -5990 {
lab=vcm}
N 5960 -6000 5960 -5990 {
lab=VDD}
N 6020 -6010 6020 -5990 {
lab=ctop}
N 6320 -6010 6320 -5990 {
lab=vcm}
N 6300 -6000 6300 -5990 {
lab=VDD}
N 6360 -6010 6360 -5990 {
lab=ctop}
N 5630 -6010 5630 -5990 {
lab=vcm}
N 5610 -6000 5610 -5990 {
lab=VDD}
N 5670 -6010 5670 -5990 {
lab=ctop}
N 5280 -6010 5280 -5990 {
lab=vcm}
N 5260 -6000 5260 -5990 {
lab=VDD}
N 5320 -6010 5320 -5990 {
lab=ctop}
N 4950 -6010 4950 -5990 {
lab=vcm}
N 4930 -6000 4930 -5990 {
lab=VDD}
N 4990 -6010 4990 -5990 {
lab=ctop}
N 4620 -6010 4620 -5990 {
lab=vcm}
N 4600 -6000 4600 -5990 {
lab=VDD}
N 4660 -6010 4660 -5990 {
lab=ctop}
N 4260 -6010 4260 -5990 {
lab=vcm}
N 4240 -6000 4240 -5990 {
lab=VDD}
N 4300 -6010 4300 -5990 {
lab=ctop}
N 3910 -6010 3910 -5990 {
lab=vcm}
N 3890 -6000 3890 -5990 {
lab=VDD}
N 3950 -6010 3950 -5990 {
lab=ctop}
N 3570 -6010 3570 -5990 {
lab=vcm}
N 3550 -6000 3550 -5990 {
lab=VDD}
N 3610 -6010 3610 -5990 {
lab=ctop}
N 3220 -6010 3220 -5990 {
lab=vcm}
N 3200 -6000 3200 -5990 {
lab=VDD}
N 3260 -6010 3260 -5990 {
lab=ctop}
N 2870 -6010 2870 -5990 {
lab=vcm}
N 2850 -6000 2850 -5990 {
lab=VDD}
N 2910 -6010 2910 -5990 {
lab=ctop}
N 2520 -6010 2520 -5990 {
lab=vcm}
N 2500 -6000 2500 -5990 {
lab=VDD}
N 2560 -6010 2560 -5990 {
lab=ctop}
N 2190 -6010 2190 -5990 {
lab=vcm}
N 2170 -6000 2170 -5990 {
lab=VDD}
N 2230 -6010 2230 -5990 {
lab=ctop}
N 1870 -6010 1870 -5990 {
lab=vcm}
N 1850 -6000 1850 -5990 {
lab=VDD}
N 1910 -6010 1910 -5990 {
lab=ctop}
N 1790 -5850 1810 -5850 {
lab=sample_n}
N 1790 -5870 1810 -5870 {
lab=sample}
N 1790 -5890 1810 -5890 {
lab=rowon_n[8]}
N 1790 -5910 1810 -5910 {
lab=row_n[8]}
N 1790 -5930 1810 -5930 {
lab=rowoff_n[8]}
N 2030 -5870 2130 -5870 {lab=#net15}
N 2030 -5850 2130 -5850 {lab=#net16}
N 1810 -5930 1820 -5940 {lab=rowoff_n[8]}
N 1820 -5940 2040 -5940 {lab=rowoff_n[8]}
N 2040 -5940 2050 -5930 {lab=rowoff_n[8]}
N 2050 -5930 2130 -5930 {lab=rowoff_n[8]}
N 1810 -5910 1820 -5920 {lab=row_n[8]}
N 1820 -5920 2040 -5920 {lab=row_n[8]}
N 2040 -5920 2050 -5910 {lab=row_n[8]}
N 2050 -5910 2130 -5910 {lab=row_n[8]}
N 1810 -5890 1820 -5900 {lab=rowon_n[8]}
N 1820 -5900 2040 -5900 {lab=rowon_n[8]}
N 2040 -5900 2050 -5890 {lab=rowon_n[8]}
N 2050 -5890 2130 -5890 {lab=rowon_n[8]}
N 2130 -5930 2140 -5940 {lab=rowoff_n[8]}
N 2130 -5910 2140 -5920 {lab=row_n[8]}
N 2140 -5920 2340 -5920 {lab=row_n[8]}
N 2340 -5920 2350 -5910 {lab=row_n[8]}
N 2350 -5910 2460 -5910 {lab=row_n[8]}
N 2140 -5940 2340 -5940 {lab=rowoff_n[8]}
N 2340 -5940 2350 -5930 {lab=rowoff_n[8]}
N 2350 -5930 2460 -5930 {lab=rowoff_n[8]}
N 2130 -5890 2140 -5900 {lab=rowon_n[8]}
N 2140 -5900 2340 -5900 {lab=rowon_n[8]}
N 2340 -5900 2350 -5890 {lab=rowon_n[8]}
N 2350 -5890 2460 -5890 {lab=rowon_n[8]}
N 2130 -5870 2140 -5880 {lab=#net15}
N 2140 -5880 2340 -5880 {lab=#net15}
N 2340 -5880 2350 -5870 {lab=#net15}
N 2350 -5870 2460 -5870 {lab=#net15}
N 2130 -5850 2140 -5860 {lab=#net16}
N 2140 -5860 2340 -5860 {lab=#net16}
N 2340 -5860 2350 -5850 {lab=#net16}
N 2350 -5850 2460 -5850 {lab=#net16}
N 2460 -5910 2470 -5920 {lab=row_n[8]}
N 2470 -5920 2670 -5920 {lab=row_n[8]}
N 2670 -5920 2680 -5910 {lab=row_n[8]}
N 2680 -5910 2810 -5910 {lab=row_n[8]}
N 2460 -5890 2470 -5900 {lab=rowon_n[8]}
N 2470 -5900 2670 -5900 {lab=rowon_n[8]}
N 2670 -5900 2680 -5890 {lab=rowon_n[8]}
N 2680 -5890 2810 -5890 {lab=rowon_n[8]}
N 2460 -5870 2470 -5880 {lab=#net15}
N 2470 -5880 2670 -5880 {lab=#net15}
N 2670 -5880 2680 -5870 {lab=#net15}
N 2680 -5870 2810 -5870 {lab=#net15}
N 2460 -5850 2480 -5860 {lab=#net16}
N 2480 -5860 2670 -5860 {lab=#net16}
N 2670 -5860 2680 -5850 {lab=#net16}
N 2680 -5850 2810 -5850 {lab=#net16}
N 2460 -5930 2470 -5940 {lab=rowoff_n[8]}
N 2470 -5940 2670 -5940 {lab=rowoff_n[8]}
N 2670 -5940 2680 -5930 {lab=rowoff_n[8]}
N 2680 -5930 2810 -5930 {lab=rowoff_n[8]}
N 2810 -5930 2820 -5940 {lab=rowoff_n[8]}
N 2820 -5940 3020 -5940 {lab=rowoff_n[8]}
N 3020 -5940 3030 -5930 {lab=rowoff_n[8]}
N 3030 -5930 3160 -5930 {lab=rowoff_n[8]}
N 2810 -5910 2820 -5920 {lab=row_n[8]}
N 2820 -5920 3020 -5920 {lab=row_n[8]}
N 3020 -5920 3030 -5910 {lab=row_n[8]}
N 3030 -5910 3160 -5910 {lab=row_n[8]}
N 2810 -5890 2820 -5900 {lab=rowon_n[8]}
N 2820 -5900 3020 -5900 {lab=rowon_n[8]}
N 3020 -5900 3030 -5890 {lab=rowon_n[8]}
N 3030 -5890 3160 -5890 {lab=rowon_n[8]}
N 2810 -5870 2820 -5880 {lab=#net15}
N 2820 -5880 3020 -5880 {lab=#net15}
N 3020 -5880 3030 -5870 {lab=#net15}
N 3030 -5870 3160 -5870 {lab=#net15}
N 2810 -5850 2820 -5860 {lab=#net16}
N 2820 -5860 3020 -5860 {lab=#net16}
N 3020 -5860 3030 -5850 {lab=#net16}
N 3030 -5850 3160 -5850 {lab=#net16}
N 3160 -5930 3170 -5940 {lab=rowoff_n[8]}
N 3170 -5940 3370 -5940 {lab=rowoff_n[8]}
N 3370 -5940 3380 -5930 {lab=rowoff_n[8]}
N 3380 -5930 3510 -5930 {lab=rowoff_n[8]}
N 3160 -5910 3170 -5920 {lab=row_n[8]}
N 3170 -5920 3370 -5920 {lab=row_n[8]}
N 3370 -5920 3380 -5910 {lab=row_n[8]}
N 3380 -5910 3510 -5910 {lab=row_n[8]}
N 3160 -5890 3170 -5900 {lab=rowon_n[8]}
N 3170 -5900 3370 -5900 {lab=rowon_n[8]}
N 3370 -5900 3380 -5890 {lab=rowon_n[8]}
N 3380 -5890 3510 -5890 {lab=rowon_n[8]}
N 3370 -5880 3380 -5870 {lab=#net15}
N 3380 -5870 3510 -5870 {lab=#net15}
N 3160 -5850 3170 -5860 {lab=#net16}
N 3170 -5860 3370 -5860 {lab=#net16}
N 3370 -5860 3380 -5850 {lab=#net16}
N 3380 -5850 3510 -5850 {lab=#net16}
N 3160 -5870 3170 -5880 {lab=#net15}
N 3170 -5880 3370 -5880 {lab=#net15}
N 3510 -5930 3520 -5940 {lab=rowoff_n[8]}
N 3520 -5940 3720 -5940 {lab=rowoff_n[8]}
N 3720 -5940 3730 -5930 {lab=rowoff_n[8]}
N 3730 -5930 3850 -5930 {lab=rowoff_n[8]}
N 3510 -5910 3520 -5920 {lab=row_n[8]}
N 3520 -5920 3720 -5920 {lab=row_n[8]}
N 3720 -5920 3730 -5910 {lab=row_n[8]}
N 3730 -5910 3850 -5910 {lab=row_n[8]}
N 3510 -5890 3520 -5900 {lab=rowon_n[8]}
N 3520 -5900 3720 -5900 {lab=rowon_n[8]}
N 3720 -5900 3730 -5890 {lab=rowon_n[8]}
N 3730 -5890 3850 -5890 {lab=rowon_n[8]}
N 3510 -5870 3520 -5880 {lab=#net15}
N 3520 -5880 3720 -5880 {lab=#net15}
N 3720 -5880 3730 -5870 {lab=#net15}
N 3730 -5870 3850 -5870 {lab=#net15}
N 3510 -5850 3520 -5860 {lab=#net16}
N 3520 -5860 3720 -5860 {lab=#net16}
N 3720 -5860 3730 -5850 {lab=#net16}
N 3730 -5850 3850 -5850 {lab=#net16}
N 3850 -5930 3860 -5940 {lab=rowoff_n[8]}
N 3860 -5940 4060 -5940 {lab=rowoff_n[8]}
N 4060 -5940 4070 -5930 {lab=rowoff_n[8]}
N 4070 -5930 4200 -5930 {lab=rowoff_n[8]}
N 3850 -5910 3860 -5920 {lab=row_n[8]}
N 3860 -5920 4060 -5920 {lab=row_n[8]}
N 4060 -5920 4070 -5910 {lab=row_n[8]}
N 4070 -5910 4200 -5910 {lab=row_n[8]}
N 3850 -5890 3860 -5900 {lab=rowon_n[8]}
N 3860 -5900 4060 -5900 {lab=rowon_n[8]}
N 4060 -5900 4070 -5890 {lab=rowon_n[8]}
N 4070 -5890 4200 -5890 {lab=rowon_n[8]}
N 3850 -5870 3860 -5880 {lab=#net15}
N 3860 -5880 4060 -5880 {lab=#net15}
N 3850 -5850 3860 -5860 {lab=#net16}
N 3860 -5860 4060 -5860 {lab=#net16}
N 4060 -5860 4070 -5850 {lab=#net16}
N 4070 -5850 4200 -5850 {lab=#net16}
N 4060 -5880 4070 -5870 {lab=#net15}
N 4070 -5870 4200 -5870 {lab=#net15}
N 4200 -5930 4210 -5940 {lab=rowoff_n[8]}
N 4210 -5940 4410 -5940 {lab=rowoff_n[8]}
N 4410 -5940 4420 -5930 {lab=rowoff_n[8]}
N 4420 -5930 4560 -5930 {lab=rowoff_n[8]}
N 4200 -5910 4210 -5920 {lab=row_n[8]}
N 4210 -5920 4410 -5920 {lab=row_n[8]}
N 4410 -5920 4420 -5910 {lab=row_n[8]}
N 4420 -5910 4560 -5910 {lab=row_n[8]}
N 4200 -5890 4210 -5900 {lab=rowon_n[8]}
N 4210 -5900 4410 -5900 {lab=rowon_n[8]}
N 4410 -5900 4420 -5890 {lab=rowon_n[8]}
N 4420 -5890 4560 -5890 {lab=rowon_n[8]}
N 4200 -5870 4210 -5880 {lab=#net15}
N 4210 -5880 4410 -5880 {lab=#net15}
N 4410 -5880 4420 -5870 {lab=#net15}
N 4420 -5870 4560 -5870 {lab=#net15}
N 4200 -5850 4210 -5860 {lab=#net16}
N 4210 -5860 4410 -5860 {lab=#net16}
N 4410 -5860 4420 -5850 {lab=#net16}
N 4420 -5850 4560 -5850 {lab=#net16}
N 4560 -5930 4570 -5940 {lab=rowoff_n[8]}
N 4570 -5940 4770 -5940 {lab=rowoff_n[8]}
N 4770 -5940 4780 -5930 {lab=rowoff_n[8]}
N 4780 -5930 4890 -5930 {lab=rowoff_n[8]}
N 4560 -5910 4570 -5920 {lab=row_n[8]}
N 4570 -5920 4770 -5920 {lab=row_n[8]}
N 4770 -5920 4780 -5910 {lab=row_n[8]}
N 4780 -5910 4890 -5910 {lab=row_n[8]}
N 4560 -5890 4570 -5900 {lab=rowon_n[8]}
N 4570 -5900 4770 -5900 {lab=rowon_n[8]}
N 4770 -5900 4780 -5890 {lab=rowon_n[8]}
N 4780 -5890 4890 -5890 {lab=rowon_n[8]}
N 4560 -5870 4570 -5880 {lab=#net15}
N 4570 -5880 4770 -5880 {lab=#net15}
N 4770 -5880 4780 -5870 {lab=#net15}
N 4780 -5870 4890 -5870 {lab=#net15}
N 4560 -5850 4570 -5860 {lab=#net16}
N 4570 -5860 4770 -5860 {lab=#net16}
N 4770 -5860 4780 -5850 {lab=#net16}
N 4780 -5850 4890 -5850 {lab=#net16}
N 4890 -5930 4900 -5940 {lab=rowoff_n[8]}
N 4900 -5940 5100 -5940 {lab=rowoff_n[8]}
N 5100 -5940 5110 -5930 {lab=rowoff_n[8]}
N 5110 -5930 5220 -5930 {lab=rowoff_n[8]}
N 4890 -5910 4900 -5920 {lab=row_n[8]}
N 4900 -5920 5100 -5920 {lab=row_n[8]}
N 5100 -5920 5110 -5910 {lab=row_n[8]}
N 5110 -5910 5220 -5910 {lab=row_n[8]}
N 4890 -5890 4900 -5900 {lab=rowon_n[8]}
N 4900 -5900 5100 -5900 {lab=rowon_n[8]}
N 5100 -5900 5110 -5890 {lab=rowon_n[8]}
N 5110 -5890 5220 -5890 {lab=rowon_n[8]}
N 4890 -5870 4900 -5880 {lab=#net15}
N 4900 -5880 5100 -5880 {lab=#net15}
N 5100 -5880 5110 -5870 {lab=#net15}
N 5110 -5870 5220 -5870 {lab=#net15}
N 4890 -5850 4900 -5860 {lab=#net16}
N 4900 -5860 5100 -5860 {lab=#net16}
N 5100 -5860 5120 -5850 {lab=#net16}
N 5120 -5850 5220 -5850 {lab=#net16}
N 5220 -5930 5230 -5940 {lab=rowoff_n[8]}
N 5230 -5940 5430 -5940 {lab=rowoff_n[8]}
N 5430 -5940 5440 -5930 {lab=rowoff_n[8]}
N 5440 -5930 5570 -5930 {lab=rowoff_n[8]}
N 5220 -5910 5230 -5920 {lab=row_n[8]}
N 5230 -5920 5430 -5920 {lab=row_n[8]}
N 5430 -5920 5440 -5910 {lab=row_n[8]}
N 5440 -5910 5570 -5910 {lab=row_n[8]}
N 5220 -5890 5230 -5900 {lab=rowon_n[8]}
N 5230 -5900 5430 -5900 {lab=rowon_n[8]}
N 5430 -5900 5440 -5890 {lab=rowon_n[8]}
N 5440 -5890 5570 -5890 {lab=rowon_n[8]}
N 5220 -5870 5230 -5880 {lab=#net15}
N 5230 -5880 5430 -5880 {lab=#net15}
N 5430 -5880 5440 -5870 {lab=#net15}
N 5440 -5870 5570 -5870 {lab=#net15}
N 5220 -5850 5230 -5860 {lab=#net16}
N 5230 -5860 5430 -5860 {lab=#net16}
N 5430 -5860 5440 -5850 {lab=#net16}
N 5440 -5850 5570 -5850 {lab=#net16}
N 5570 -5930 5580 -5940 {lab=rowoff_n[8]}
N 5580 -5940 5780 -5940 {lab=rowoff_n[8]}
N 5780 -5940 5790 -5930 {lab=rowoff_n[8]}
N 5790 -5930 5920 -5930 {lab=rowoff_n[8]}
N 5570 -5910 5580 -5920 {lab=row_n[8]}
N 5580 -5920 5780 -5920 {lab=row_n[8]}
N 5570 -5890 5580 -5900 {lab=rowon_n[8]}
N 5580 -5900 5780 -5900 {lab=rowon_n[8]}
N 5780 -5900 5790 -5890 {lab=rowon_n[8]}
N 5790 -5890 5920 -5890 {lab=rowon_n[8]}
N 5780 -5920 5790 -5910 {lab=row_n[8]}
N 5790 -5910 5920 -5910 {lab=row_n[8]}
N 5570 -5870 5580 -5880 {lab=#net15}
N 5580 -5880 5780 -5880 {lab=#net15}
N 5780 -5880 5790 -5870 {lab=#net15}
N 5790 -5870 5920 -5870 {lab=#net15}
N 5570 -5850 5580 -5860 {lab=#net16}
N 5580 -5860 5780 -5860 {lab=#net16}
N 5780 -5860 5790 -5850 {lab=#net16}
N 5790 -5850 5920 -5850 {lab=#net16}
N 5920 -5930 5930 -5940 {lab=rowoff_n[8]}
N 5930 -5940 6130 -5940 {lab=rowoff_n[8]}
N 6130 -5940 6140 -5930 {lab=rowoff_n[8]}
N 6140 -5930 6260 -5930 {lab=rowoff_n[8]}
N 5920 -5910 5930 -5920 {lab=row_n[8]}
N 5930 -5920 6130 -5920 {lab=row_n[8]}
N 6130 -5920 6140 -5910 {lab=row_n[8]}
N 6140 -5910 6260 -5910 {lab=row_n[8]}
N 5920 -5890 5930 -5900 {lab=rowon_n[8]}
N 5930 -5900 6130 -5900 {lab=rowon_n[8]}
N 6130 -5900 6140 -5890 {lab=rowon_n[8]}
N 6140 -5890 6260 -5890 {lab=rowon_n[8]}
N 5920 -5870 5930 -5880 {lab=#net15}
N 5930 -5880 6130 -5880 {lab=#net15}
N 6130 -5880 6140 -5870 {lab=#net15}
N 6140 -5870 6260 -5870 {lab=#net15}
N 5920 -5850 5930 -5860 {lab=#net16}
N 5930 -5860 6130 -5860 {lab=#net16}
N 6130 -5860 6140 -5850 {lab=#net16}
N 6140 -5850 6260 -5850 {lab=#net16}
N 6260 -5930 6270 -5940 {lab=rowoff_n[8]}
N 6270 -5940 6470 -5940 {lab=rowoff_n[8]}
N 6470 -5940 6480 -5930 {lab=rowoff_n[8]}
N 6480 -5930 6600 -5930 {lab=rowoff_n[8]}
N 6260 -5910 6270 -5920 {lab=row_n[8]}
N 6270 -5920 6470 -5920 {lab=row_n[8]}
N 6470 -5920 6480 -5910 {lab=row_n[8]}
N 6480 -5910 6600 -5910 {lab=row_n[8]}
N 6260 -5890 6270 -5900 {lab=rowon_n[8]}
N 6270 -5900 6470 -5900 {lab=rowon_n[8]}
N 6470 -5900 6480 -5890 {lab=rowon_n[8]}
N 6480 -5890 6600 -5890 {lab=rowon_n[8]}
N 6260 -5870 6270 -5880 {lab=#net15}
N 6270 -5880 6470 -5880 {lab=#net15}
N 6470 -5880 6480 -5870 {lab=#net15}
N 6480 -5870 6600 -5870 {lab=#net15}
N 6260 -5850 6270 -5860 {lab=#net16}
N 6270 -5860 6470 -5860 {lab=#net16}
N 6470 -5860 6490 -5850 {lab=#net16}
N 6490 -5850 6600 -5850 {lab=#net16}
N 6600 -5930 6610 -5940 {lab=rowoff_n[8]}
N 6610 -5940 6810 -5940 {lab=rowoff_n[8]}
N 6600 -5910 6610 -5920 {lab=row_n[8]}
N 6610 -5920 6810 -5920 {lab=row_n[8]}
N 6810 -5920 6820 -5910 {lab=row_n[8]}
N 6810 -5940 6820 -5930 {lab=rowoff_n[8]}
N 6600 -5890 6610 -5900 {lab=rowon_n[8]}
N 6610 -5900 6810 -5900 {lab=rowon_n[8]}
N 6600 -5870 6610 -5880 {lab=#net15}
N 6610 -5880 6810 -5880 {lab=#net15}
N 6810 -5880 6820 -5870 {lab=#net15}
N 6600 -5850 6610 -5860 {lab=#net16}
N 6610 -5860 6810 -5860 {lab=#net16}
N 6810 -5860 6820 -5850 {lab=#net16}
N 6810 -5900 6820 -5890 {lab=rowon_n[8]}
N 1930 -5440 1940 -5450 {lab=VDD}
N 1940 -5700 1940 -5450 {lab=VDD}
N 1930 -5710 1940 -5700 {lab=VDD}
N 1930 -5770 1930 -5710 {lab=VDD}
N 1950 -5770 1950 -5710 {lab=VSS}
N 1950 -5710 1960 -5700 {lab=VSS}
N 1960 -5700 1960 -5450 {lab=VSS}
N 1950 -5440 1960 -5450 {lab=VSS}
N 2260 -5700 2260 -5450 {lab=col_n[0]}
N 2250 -5710 2260 -5700 {lab=col_n[0]}
N 2250 -5770 2250 -5710 {lab=col_n[0]}
N 2270 -5770 2270 -5710 {lab=col[0]}
N 2270 -5710 2280 -5700 {lab=col[0]}
N 2280 -5700 2280 -5450 {lab=col[0]}
N 2590 -5700 2590 -5450 {lab=col_n[1]}
N 2580 -5710 2590 -5700 {lab=col_n[1]}
N 2580 -5770 2580 -5710 {lab=col_n[1]}
N 2600 -5770 2600 -5710 {lab=col[1]}
N 2600 -5710 2610 -5700 {lab=col[1]}
N 2610 -5700 2610 -5450 {lab=col[1]}
N 2940 -5700 2940 -5450 {lab=col_n[2]}
N 2930 -5710 2940 -5700 {lab=col_n[2]}
N 2930 -5770 2930 -5710 {lab=col_n[2]}
N 2950 -5770 2950 -5710 {lab=col[2]}
N 2950 -5710 2960 -5700 {lab=col[2]}
N 2960 -5700 2960 -5450 {lab=col[2]}
N 3290 -5700 3290 -5450 {lab=col_n[3]}
N 3280 -5710 3290 -5700 {lab=col_n[3]}
N 3280 -5770 3280 -5710 {lab=col_n[3]}
N 3300 -5770 3300 -5710 {lab=col[3]}
N 3300 -5710 3310 -5700 {lab=col[3]}
N 3310 -5700 3310 -5450 {lab=col[3]}
N 3640 -5700 3640 -5450 {lab=col_n[4]}
N 3630 -5710 3640 -5700 {lab=col_n[4]}
N 3630 -5770 3630 -5710 {lab=col_n[4]}
N 3650 -5770 3650 -5710 {lab=col[4]}
N 3650 -5710 3660 -5700 {lab=col[4]}
N 3660 -5700 3660 -5450 {lab=col[4]}
N 3980 -5700 3980 -5450 {lab=col_n[5]}
N 3970 -5710 3980 -5700 {lab=col_n[5]}
N 3970 -5770 3970 -5710 {lab=col_n[5]}
N 3990 -5770 3990 -5710 {lab=col[5]}
N 3990 -5710 4000 -5700 {lab=col[5]}
N 4000 -5700 4000 -5450 {lab=col[5]}
N 4330 -5700 4330 -5450 {lab=col_n[6]}
N 4320 -5710 4330 -5700 {lab=col_n[6]}
N 4320 -5770 4320 -5710 {lab=col_n[6]}
N 4340 -5770 4340 -5710 {lab=col[6]}
N 4340 -5710 4350 -5700 {lab=col[6]}
N 4350 -5700 4350 -5450 {lab=col[6]}
N 4690 -5700 4690 -5450 {lab=col_n[7]}
N 4680 -5710 4690 -5700 {lab=col_n[7]}
N 4680 -5770 4680 -5710 {lab=col_n[7]}
N 4700 -5770 4700 -5710 {lab=col[7]}
N 4700 -5710 4710 -5700 {lab=col[7]}
N 4710 -5700 4710 -5450 {lab=col[7]}
N 5020 -5700 5020 -5450 {lab=col_n[8]}
N 5010 -5710 5020 -5700 {lab=col_n[8]}
N 5010 -5770 5010 -5710 {lab=col_n[8]}
N 5030 -5770 5030 -5710 {lab=col[8]}
N 5030 -5710 5040 -5700 {lab=col[8]}
N 5040 -5700 5040 -5450 {lab=col[8]}
N 5350 -5700 5350 -5450 {lab=col_n[9]}
N 5340 -5710 5350 -5700 {lab=col_n[9]}
N 5340 -5770 5340 -5710 {lab=col_n[9]}
N 5360 -5770 5360 -5710 {lab=col[9]}
N 5360 -5710 5370 -5700 {lab=col[9]}
N 5370 -5700 5370 -5450 {lab=col[9]}
N 5700 -5700 5700 -5450 {lab=col_n[10]}
N 5690 -5710 5700 -5700 {lab=col_n[10]}
N 5690 -5770 5690 -5710 {lab=col_n[10]}
N 5710 -5770 5710 -5710 {lab=col[10]}
N 5710 -5710 5720 -5700 {lab=col[10]}
N 5720 -5700 5720 -5450 {lab=col[10]}
N 6050 -5700 6050 -5450 {lab=col_n[11]}
N 6040 -5710 6050 -5700 {lab=col_n[11]}
N 6040 -5770 6040 -5710 {lab=col_n[11]}
N 6060 -5770 6060 -5710 {lab=col[11]}
N 6060 -5710 6070 -5700 {lab=col[11]}
N 6070 -5700 6070 -5450 {lab=col[11]}
N 6390 -5700 6390 -5450 {lab=col_n[12]}
N 6380 -5710 6390 -5700 {lab=col_n[12]}
N 6380 -5770 6380 -5710 {lab=col_n[12]}
N 6400 -5770 6400 -5710 {lab=col[12]}
N 6400 -5710 6410 -5700 {lab=col[12]}
N 6410 -5700 6410 -5450 {lab=col[12]}
N 6730 -5700 6730 -5450 {lab=VDD}
N 6720 -5710 6730 -5700 {lab=VDD}
N 6720 -5770 6720 -5710 {lab=VDD}
N 6740 -5770 6740 -5710 {lab=VSS}
N 6740 -5710 6750 -5700 {lab=VSS}
N 6750 -5700 6750 -5450 {lab=VSS}
N 6740 -5440 6750 -5450 {lab=VSS}
N 6720 -5440 6730 -5450 {lab=VDD}
N 6380 -5440 6390 -5450 {lab=col_n[12]}
N 6400 -5440 6410 -5450 {lab=col[12]}
N 6040 -5440 6050 -5450 {lab=col_n[11]}
N 6060 -5440 6070 -5450 {lab=col[11]}
N 5690 -5440 5700 -5450 {lab=col_n[10]}
N 5710 -5440 5720 -5450 {lab=col[10]}
N 5360 -5440 5370 -5450 {lab=col[9]}
N 5340 -5440 5350 -5450 {lab=col_n[9]}
N 5030 -5440 5040 -5450 {lab=col[8]}
N 5010 -5440 5020 -5450 {lab=col_n[8]}
N 4680 -5440 4690 -5450 {lab=col_n[7]}
N 4700 -5440 4710 -5450 {lab=col[7]}
N 4320 -5440 4330 -5450 {lab=col_n[6]}
N 4340 -5440 4350 -5450 {lab=col[6]}
N 3990 -5440 4000 -5450 {lab=col[5]}
N 3970 -5440 3980 -5450 {lab=col_n[5]}
N 3650 -5440 3660 -5450 {lab=col[4]}
N 3630 -5440 3640 -5450 {lab=col_n[4]}
N 3300 -5440 3310 -5450 {lab=col[3]}
N 3280 -5440 3290 -5450 {lab=col_n[3]}
N 2950 -5440 2960 -5450 {lab=col[2]}
N 2930 -5440 2940 -5450 {lab=col_n[2]}
N 2600 -5440 2610 -5450 {lab=col[1]}
N 2580 -5440 2590 -5450 {lab=col_n[1]}
N 2250 -5440 2260 -5450 {lab=col_n[0]}
N 2270 -5440 2280 -5450 {lab=col[0]}
N 1930 -5440 1930 -5400 {lab=VDD}
N 1950 -5440 1950 -5400 {lab=VSS}
N 1930 -5120 1940 -5130 {lab=VDD}
N 1940 -5390 1940 -5130 {lab=VDD}
N 1930 -5400 1940 -5390 {lab=VDD}
N 1950 -5400 1960 -5390 {lab=VSS}
N 1960 -5390 1960 -5130 {lab=VSS}
N 1950 -5120 1960 -5130 {lab=VSS}
N 2250 -5440 2250 -5400 {lab=col_n[0]}
N 2270 -5440 2270 -5400 {lab=col[0]}
N 2260 -5390 2260 -5130 {lab=col_n[0]}
N 2250 -5400 2260 -5390 {lab=col_n[0]}
N 2270 -5400 2280 -5390 {lab=col[0]}
N 2280 -5390 2280 -5130 {lab=col[0]}
N 2580 -5440 2580 -5400 {lab=col_n[1]}
N 2600 -5440 2600 -5400 {lab=col[1]}
N 2590 -5390 2590 -5130 {lab=col_n[1]}
N 2580 -5400 2590 -5390 {lab=col_n[1]}
N 2600 -5400 2610 -5390 {lab=col[1]}
N 2610 -5390 2610 -5130 {lab=col[1]}
N 2930 -5440 2930 -5400 {lab=col_n[2]}
N 2950 -5440 2950 -5400 {lab=col[2]}
N 2940 -5390 2940 -5130 {lab=col_n[2]}
N 2930 -5400 2940 -5390 {lab=col_n[2]}
N 2950 -5400 2960 -5390 {lab=col[2]}
N 2960 -5390 2960 -5130 {lab=col[2]}
N 3280 -5440 3280 -5400 {lab=col_n[3]}
N 3300 -5440 3300 -5400 {lab=col[3]}
N 3290 -5390 3290 -5130 {lab=col_n[3]}
N 3280 -5400 3290 -5390 {lab=col_n[3]}
N 3300 -5400 3310 -5390 {lab=col[3]}
N 3310 -5390 3310 -5130 {lab=col[3]}
N 3630 -5440 3630 -5400 {lab=col_n[4]}
N 3650 -5440 3650 -5400 {lab=col[4]}
N 3640 -5390 3640 -5130 {lab=col_n[4]}
N 3630 -5400 3640 -5390 {lab=col_n[4]}
N 3650 -5400 3660 -5390 {lab=col[4]}
N 3660 -5390 3660 -5130 {lab=col[4]}
N 3970 -5440 3970 -5400 {lab=col_n[5]}
N 3990 -5440 3990 -5400 {lab=col[5]}
N 3980 -5390 3980 -5130 {lab=col_n[5]}
N 3970 -5400 3980 -5390 {lab=col_n[5]}
N 3990 -5400 4000 -5390 {lab=col[5]}
N 4000 -5390 4000 -5130 {lab=col[5]}
N 4320 -5440 4320 -5400 {lab=col_n[6]}
N 4340 -5440 4340 -5400 {lab=col[6]}
N 4330 -5390 4330 -5130 {lab=col_n[6]}
N 4320 -5400 4330 -5390 {lab=col_n[6]}
N 4340 -5400 4350 -5390 {lab=col[6]}
N 4350 -5390 4350 -5130 {lab=col[6]}
N 4680 -5440 4680 -5400 {lab=col_n[7]}
N 4700 -5440 4700 -5400 {lab=col[7]}
N 4690 -5390 4690 -5130 {lab=col_n[7]}
N 4680 -5400 4690 -5390 {lab=col_n[7]}
N 4700 -5400 4710 -5390 {lab=col[7]}
N 4710 -5390 4710 -5130 {lab=col[7]}
N 5010 -5440 5010 -5400 {lab=col_n[8]}
N 5030 -5440 5030 -5400 {lab=col[8]}
N 5020 -5390 5020 -5130 {lab=col_n[8]}
N 5010 -5400 5020 -5390 {lab=col_n[8]}
N 5030 -5400 5040 -5390 {lab=col[8]}
N 5040 -5390 5040 -5130 {lab=col[8]}
N 5690 -5440 5690 -5400 {lab=col_n[10]}
N 5710 -5440 5710 -5400 {lab=col[10]}
N 5700 -5390 5700 -5130 {lab=col_n[10]}
N 5690 -5400 5700 -5390 {lab=col_n[10]}
N 5710 -5400 5720 -5390 {lab=col[10]}
N 5720 -5390 5720 -5130 {lab=col[10]}
N 6040 -5440 6040 -5400 {lab=col_n[11]}
N 6060 -5440 6060 -5400 {lab=col[11]}
N 6050 -5390 6050 -5130 {lab=col_n[11]}
N 6040 -5400 6050 -5390 {lab=col_n[11]}
N 6060 -5400 6070 -5390 {lab=col[11]}
N 6070 -5390 6070 -5130 {lab=col[11]}
N 6380 -5440 6380 -5400 {lab=col_n[12]}
N 6400 -5440 6400 -5400 {lab=col[12]}
N 6390 -5390 6390 -5130 {lab=col_n[12]}
N 6380 -5400 6390 -5390 {lab=col_n[12]}
N 6400 -5400 6410 -5390 {lab=col[12]}
N 6410 -5390 6410 -5130 {lab=col[12]}
N 6720 -5440 6720 -5400 {lab=VDD}
N 6740 -5440 6740 -5400 {lab=VSS}
N 6730 -5390 6730 -5130 {lab=VDD}
N 6720 -5400 6730 -5390 {lab=VDD}
N 6740 -5400 6750 -5390 {lab=VSS}
N 6750 -5390 6750 -5130 {lab=VSS}
N 6740 -5120 6750 -5130 {lab=VSS}
N 6720 -5120 6730 -5130 {lab=VDD}
N 6400 -5120 6410 -5130 {lab=col[12]}
N 6380 -5120 6390 -5130 {lab=col_n[12]}
N 6060 -5120 6070 -5130 {lab=col[11]}
N 6040 -5120 6050 -5130 {lab=col_n[11]}
N 5710 -5120 5720 -5130 {lab=col[10]}
N 5690 -5120 5700 -5130 {lab=col_n[10]}
N 5340 -5440 5340 -5400 {lab=col_n[9]}
N 5360 -5440 5360 -5400 {lab=col[9]}
N 5350 -5390 5350 -5130 {lab=col_n[9]}
N 5340 -5400 5350 -5390 {lab=col_n[9]}
N 5360 -5400 5370 -5390 {lab=col[9]}
N 5370 -5390 5370 -5130 {lab=col[9]}
N 5360 -5120 5370 -5130 {lab=col[9]}
N 5340 -5120 5350 -5130 {lab=col_n[9]}
N 5030 -5120 5040 -5130 {lab=col[8]}
N 5010 -5120 5020 -5130 {lab=col_n[8]}
N 4700 -5120 4710 -5130 {lab=col[7]}
N 4680 -5120 4690 -5130 {lab=col_n[7]}
N 4340 -5120 4350 -5130 {lab=col[6]}
N 4320 -5120 4330 -5130 {lab=col_n[6]}
N 3990 -5120 4000 -5130 {lab=col[5]}
N 3970 -5120 3980 -5130 {lab=col_n[5]}
N 3650 -5120 3660 -5130 {lab=col[4]}
N 3630 -5120 3640 -5130 {lab=col_n[4]}
N 2250 -5120 2260 -5130 {lab=col_n[0]}
N 2270 -5120 2280 -5130 {lab=col[0]}
N 2580 -5120 2590 -5130 {lab=col_n[1]}
N 2600 -5120 2610 -5130 {lab=col[1]}
N 2930 -5120 2940 -5130 {lab=col_n[2]}
N 2950 -5120 2960 -5130 {lab=col[2]}
N 3280 -5120 3290 -5130 {lab=col_n[3]}
N 3300 -5120 3310 -5130 {lab=col[3]}
N 1930 -4440 1940 -4450 {lab=VDD}
N 1940 -4740 1940 -4450 {lab=VDD}
N 1930 -4750 1940 -4740 {lab=VDD}
N 1950 -4440 1960 -4450 {lab=VSS}
N 1960 -4740 1960 -4450 {lab=VSS}
N 1950 -4750 1960 -4740 {lab=VSS}
N 2250 -4790 2250 -4750 {lab=col_n[0]}
N 2270 -4790 2270 -4750 {lab=col[0]}
N 2260 -4740 2260 -4450 {lab=col_n[0]}
N 2250 -4750 2260 -4740 {lab=col_n[0]}
N 2280 -4740 2280 -4450 {lab=col[0]}
N 2270 -4750 2280 -4740 {lab=col[0]}
N 2580 -4790 2580 -4750 {lab=col_n[1]}
N 2600 -4790 2600 -4750 {lab=col[1]}
N 2590 -4740 2590 -4450 {lab=col_n[1]}
N 2580 -4750 2590 -4740 {lab=col_n[1]}
N 2610 -4740 2610 -4450 {lab=col[1]}
N 2600 -4750 2610 -4740 {lab=col[1]}
N 2930 -4790 2930 -4750 {lab=col_n[2]}
N 2950 -4790 2950 -4750 {lab=col[2]}
N 2940 -4740 2940 -4450 {lab=col_n[2]}
N 2930 -4750 2940 -4740 {lab=col_n[2]}
N 2960 -4740 2960 -4450 {lab=col[2]}
N 2950 -4750 2960 -4740 {lab=col[2]}
N 3280 -4790 3280 -4750 {lab=col_n[3]}
N 3300 -4790 3300 -4750 {lab=col[3]}
N 3290 -4740 3290 -4450 {lab=col_n[3]}
N 3280 -4750 3290 -4740 {lab=col_n[3]}
N 3310 -4740 3310 -4450 {lab=col[3]}
N 3300 -4750 3310 -4740 {lab=col[3]}
N 3630 -4790 3630 -4750 {lab=col_n[4]}
N 3650 -4790 3650 -4750 {lab=col[4]}
N 3640 -4740 3640 -4450 {lab=col_n[4]}
N 3630 -4750 3640 -4740 {lab=col_n[4]}
N 3660 -4740 3660 -4450 {lab=col[4]}
N 3650 -4750 3660 -4740 {lab=col[4]}
N 3970 -4790 3970 -4750 {lab=col_n[5]}
N 3990 -4790 3990 -4750 {lab=col[5]}
N 3980 -4740 3980 -4450 {lab=col_n[5]}
N 3970 -4750 3980 -4740 {lab=col_n[5]}
N 4000 -4740 4000 -4450 {lab=col[5]}
N 3990 -4750 4000 -4740 {lab=col[5]}
N 4320 -4790 4320 -4750 {lab=col_n[6]}
N 4340 -4790 4340 -4750 {lab=col[6]}
N 4330 -4740 4330 -4450 {lab=col_n[6]}
N 4320 -4750 4330 -4740 {lab=col_n[6]}
N 4350 -4740 4350 -4450 {lab=col[6]}
N 4340 -4750 4350 -4740 {lab=col[6]}
N 4680 -4790 4680 -4750 {lab=col_n[7]}
N 4700 -4790 4700 -4750 {lab=col[7]}
N 4690 -4740 4690 -4450 {lab=col_n[7]}
N 4680 -4750 4690 -4740 {lab=col_n[7]}
N 4710 -4740 4710 -4450 {lab=col[7]}
N 4700 -4750 4710 -4740 {lab=col[7]}
N 5010 -4790 5010 -4750 {lab=col_n[8]}
N 5030 -4790 5030 -4750 {lab=col[8]}
N 5020 -4740 5020 -4450 {lab=col_n[8]}
N 5010 -4750 5020 -4740 {lab=col_n[8]}
N 5040 -4740 5040 -4450 {lab=col[8]}
N 5030 -4750 5040 -4740 {lab=col[8]}
N 5340 -4790 5340 -4750 {lab=col_n[9]}
N 5360 -4790 5360 -4750 {lab=col[9]}
N 5350 -4740 5350 -4450 {lab=col_n[9]}
N 5340 -4750 5350 -4740 {lab=col_n[9]}
N 5370 -4740 5370 -4450 {lab=col[9]}
N 5360 -4750 5370 -4740 {lab=col[9]}
N 5690 -4790 5690 -4750 {lab=col_n[10]}
N 5710 -4790 5710 -4750 {lab=col[10]}
N 5700 -4740 5700 -4450 {lab=col_n[10]}
N 5690 -4750 5700 -4740 {lab=col_n[10]}
N 5720 -4740 5720 -4450 {lab=col[10]}
N 5710 -4750 5720 -4740 {lab=col[10]}
N 6040 -4790 6040 -4750 {lab=col_n[11]}
N 6060 -4790 6060 -4750 {lab=col[11]}
N 6050 -4740 6050 -4450 {lab=col_n[11]}
N 6040 -4750 6050 -4740 {lab=col_n[11]}
N 6070 -4740 6070 -4450 {lab=col[11]}
N 6060 -4750 6070 -4740 {lab=col[11]}
N 6380 -4790 6380 -4750 {lab=col_n[12]}
N 6400 -4790 6400 -4750 {lab=col[12]}
N 6390 -4740 6390 -4450 {lab=col_n[12]}
N 6380 -4750 6390 -4740 {lab=col_n[12]}
N 6410 -4740 6410 -4450 {lab=col[12]}
N 6400 -4750 6410 -4740 {lab=col[12]}
N 6720 -4790 6720 -4750 {lab=VDD}
N 6740 -4790 6740 -4750 {lab=VSS}
N 6730 -4740 6730 -4450 {lab=VDD}
N 6720 -4750 6730 -4740 {lab=VDD}
N 6750 -4740 6750 -4450 {lab=VSS}
N 6740 -4750 6750 -4740 {lab=VSS}
N 2250 -4440 2260 -4450 {lab=col_n[0]}
N 2270 -4440 2280 -4450 {lab=col[0]}
N 2580 -4440 2590 -4450 {lab=col_n[1]}
N 2600 -4440 2610 -4450 {lab=col[1]}
N 2930 -4440 2940 -4450 {lab=col_n[2]}
N 2950 -4440 2960 -4450 {lab=col[2]}
N 3280 -4440 3290 -4450 {lab=col_n[3]}
N 3300 -4440 3310 -4450 {lab=col[3]}
N 3630 -4440 3640 -4450 {lab=col_n[4]}
N 3650 -4440 3660 -4450 {lab=col[4]}
N 3970 -4440 3980 -4450 {lab=col_n[5]}
N 3990 -4440 4000 -4450 {lab=col[5]}
N 4680 -4440 4690 -4450 {lab=col_n[7]}
N 4700 -4440 4710 -4450 {lab=col[7]}
N 4320 -4440 4330 -4450 {lab=col_n[6]}
N 4340 -4440 4350 -4450 {lab=col[6]}
N 5010 -4440 5020 -4450 {lab=col_n[8]}
N 5030 -4440 5040 -4450 {lab=col[8]}
N 5360 -4440 5370 -4450 {lab=col[9]}
N 5340 -4440 5350 -4450 {lab=col_n[9]}
N 5690 -4440 5700 -4450 {lab=col_n[10]}
N 5710 -4440 5720 -4450 {lab=col[10]}
N 6040 -4440 6050 -4450 {lab=col_n[11]}
N 6060 -4440 6070 -4450 {lab=col[11]}
N 6380 -4440 6390 -4450 {lab=col_n[12]}
N 6400 -4440 6410 -4450 {lab=col[12]}
N 6720 -4440 6730 -4450 {lab=VDD}
N 6740 -4440 6750 -4450 {lab=VSS}
N 1850 -6080 1850 -6070 {
lab=VSS}
N 2170 -6080 2170 -6070 {
lab=VSS}
N 2500 -6080 2500 -6070 {
lab=VSS}
N 2850 -6080 2850 -6070 {
lab=VSS}
N 3200 -6080 3200 -6070 {
lab=VSS}
N 3550 -6080 3550 -6070 {
lab=VSS}
N 3890 -6080 3890 -6070 {
lab=VSS}
N 4240 -6080 4240 -6070 {
lab=VSS}
N 4600 -6080 4600 -6070 {
lab=VSS}
N 4930 -6080 4930 -6070 {
lab=VSS}
N 5260 -6080 5260 -6070 {
lab=VSS}
N 5610 -6080 5610 -6070 {
lab=VSS}
N 5960 -6080 5960 -6070 {
lab=VSS}
N 6300 -6080 6300 -6070 {
lab=VSS}
N 6640 -6080 6640 -6070 {
lab=VSS}
N 6660 -6320 6660 -6300 {
lab=vcm}
N 6640 -6310 6640 -6300 {
lab=VDD}
N 6700 -6320 6700 -6300 {
lab=ctop}
N 5980 -6320 5980 -6300 {
lab=vcm}
N 5960 -6310 5960 -6300 {
lab=VDD}
N 6020 -6320 6020 -6300 {
lab=ctop}
N 6320 -6320 6320 -6300 {
lab=vcm}
N 6300 -6310 6300 -6300 {
lab=VDD}
N 6360 -6320 6360 -6300 {
lab=ctop}
N 5630 -6320 5630 -6300 {
lab=vcm}
N 5610 -6310 5610 -6300 {
lab=VDD}
N 5670 -6320 5670 -6300 {
lab=ctop}
N 5280 -6320 5280 -6300 {
lab=vcm}
N 5260 -6310 5260 -6300 {
lab=VDD}
N 5320 -6320 5320 -6300 {
lab=ctop}
N 4950 -6320 4950 -6300 {
lab=vcm}
N 4930 -6310 4930 -6300 {
lab=VDD}
N 4990 -6320 4990 -6300 {
lab=ctop}
N 4620 -6320 4620 -6300 {
lab=vcm}
N 4600 -6310 4600 -6300 {
lab=VDD}
N 4660 -6320 4660 -6300 {
lab=ctop}
N 4260 -6320 4260 -6300 {
lab=vcm}
N 4240 -6310 4240 -6300 {
lab=VDD}
N 4300 -6320 4300 -6300 {
lab=ctop}
N 3910 -6320 3910 -6300 {
lab=vcm}
N 3890 -6310 3890 -6300 {
lab=VDD}
N 3950 -6320 3950 -6300 {
lab=ctop}
N 3570 -6320 3570 -6300 {
lab=vcm}
N 3550 -6310 3550 -6300 {
lab=VDD}
N 3610 -6320 3610 -6300 {
lab=ctop}
N 3220 -6320 3220 -6300 {
lab=vcm}
N 3200 -6310 3200 -6300 {
lab=VDD}
N 3260 -6320 3260 -6300 {
lab=ctop}
N 2870 -6320 2870 -6300 {
lab=vcm}
N 2850 -6310 2850 -6300 {
lab=VDD}
N 2910 -6320 2910 -6300 {
lab=ctop}
N 2520 -6320 2520 -6300 {
lab=vcm}
N 2500 -6310 2500 -6300 {
lab=VDD}
N 2560 -6320 2560 -6300 {
lab=ctop}
N 2190 -6320 2190 -6300 {
lab=vcm}
N 2170 -6310 2170 -6300 {
lab=VDD}
N 2230 -6320 2230 -6300 {
lab=ctop}
N 1870 -6320 1870 -6300 {
lab=vcm}
N 1850 -6310 1850 -6300 {
lab=VDD}
N 1910 -6320 1910 -6300 {
lab=ctop}
N 1790 -6160 1810 -6160 {
lab=sample_n}
N 1790 -6180 1810 -6180 {
lab=sample}
N 1790 -6200 1810 -6200 {
lab=rowon_n[9]}
N 1790 -6220 1810 -6220 {
lab=row_n[9]}
N 1790 -6240 1810 -6240 {
lab=rowoff_n[9]}
N 2030 -6180 2130 -6180 {lab=#net17}
N 2030 -6160 2130 -6160 {lab=#net18}
N 1810 -6240 1820 -6250 {lab=rowoff_n[9]}
N 1820 -6250 2040 -6250 {lab=rowoff_n[9]}
N 2040 -6250 2050 -6240 {lab=rowoff_n[9]}
N 2050 -6240 2130 -6240 {lab=rowoff_n[9]}
N 1810 -6220 1820 -6230 {lab=row_n[9]}
N 1820 -6230 2040 -6230 {lab=row_n[9]}
N 2040 -6230 2050 -6220 {lab=row_n[9]}
N 2050 -6220 2130 -6220 {lab=row_n[9]}
N 1810 -6200 1820 -6210 {lab=rowon_n[9]}
N 1820 -6210 2040 -6210 {lab=rowon_n[9]}
N 2040 -6210 2050 -6200 {lab=rowon_n[9]}
N 2050 -6200 2130 -6200 {lab=rowon_n[9]}
N 2130 -6240 2140 -6250 {lab=rowoff_n[9]}
N 2130 -6220 2140 -6230 {lab=row_n[9]}
N 2140 -6230 2340 -6230 {lab=row_n[9]}
N 2340 -6230 2350 -6220 {lab=row_n[9]}
N 2350 -6220 2460 -6220 {lab=row_n[9]}
N 2140 -6250 2340 -6250 {lab=rowoff_n[9]}
N 2340 -6250 2350 -6240 {lab=rowoff_n[9]}
N 2350 -6240 2460 -6240 {lab=rowoff_n[9]}
N 2130 -6200 2140 -6210 {lab=rowon_n[9]}
N 2140 -6210 2340 -6210 {lab=rowon_n[9]}
N 2340 -6210 2350 -6200 {lab=rowon_n[9]}
N 2350 -6200 2460 -6200 {lab=rowon_n[9]}
N 2130 -6180 2140 -6190 {lab=#net17}
N 2140 -6190 2340 -6190 {lab=#net17}
N 2340 -6190 2350 -6180 {lab=#net17}
N 2350 -6180 2460 -6180 {lab=#net17}
N 2130 -6160 2140 -6170 {lab=#net18}
N 2140 -6170 2340 -6170 {lab=#net18}
N 2340 -6170 2350 -6160 {lab=#net18}
N 2350 -6160 2460 -6160 {lab=#net18}
N 2460 -6220 2470 -6230 {lab=row_n[9]}
N 2470 -6230 2670 -6230 {lab=row_n[9]}
N 2670 -6230 2680 -6220 {lab=row_n[9]}
N 2680 -6220 2810 -6220 {lab=row_n[9]}
N 2460 -6200 2470 -6210 {lab=rowon_n[9]}
N 2470 -6210 2670 -6210 {lab=rowon_n[9]}
N 2670 -6210 2680 -6200 {lab=rowon_n[9]}
N 2680 -6200 2810 -6200 {lab=rowon_n[9]}
N 2460 -6180 2470 -6190 {lab=#net17}
N 2470 -6190 2670 -6190 {lab=#net17}
N 2670 -6190 2680 -6180 {lab=#net17}
N 2680 -6180 2810 -6180 {lab=#net17}
N 2460 -6160 2480 -6170 {lab=#net18}
N 2480 -6170 2670 -6170 {lab=#net18}
N 2670 -6170 2680 -6160 {lab=#net18}
N 2680 -6160 2810 -6160 {lab=#net18}
N 2460 -6240 2470 -6250 {lab=rowoff_n[9]}
N 2470 -6250 2670 -6250 {lab=rowoff_n[9]}
N 2670 -6250 2680 -6240 {lab=rowoff_n[9]}
N 2680 -6240 2810 -6240 {lab=rowoff_n[9]}
N 2810 -6240 2820 -6250 {lab=rowoff_n[9]}
N 2820 -6250 3020 -6250 {lab=rowoff_n[9]}
N 3020 -6250 3030 -6240 {lab=rowoff_n[9]}
N 3030 -6240 3160 -6240 {lab=rowoff_n[9]}
N 2810 -6220 2820 -6230 {lab=row_n[9]}
N 2820 -6230 3020 -6230 {lab=row_n[9]}
N 3020 -6230 3030 -6220 {lab=row_n[9]}
N 3030 -6220 3160 -6220 {lab=row_n[9]}
N 2810 -6200 2820 -6210 {lab=rowon_n[9]}
N 2820 -6210 3020 -6210 {lab=rowon_n[9]}
N 3020 -6210 3030 -6200 {lab=rowon_n[9]}
N 3030 -6200 3160 -6200 {lab=rowon_n[9]}
N 2810 -6180 2820 -6190 {lab=#net17}
N 2820 -6190 3020 -6190 {lab=#net17}
N 3020 -6190 3030 -6180 {lab=#net17}
N 3030 -6180 3160 -6180 {lab=#net17}
N 2810 -6160 2820 -6170 {lab=#net18}
N 2820 -6170 3020 -6170 {lab=#net18}
N 3020 -6170 3030 -6160 {lab=#net18}
N 3030 -6160 3160 -6160 {lab=#net18}
N 3160 -6240 3170 -6250 {lab=rowoff_n[9]}
N 3170 -6250 3370 -6250 {lab=rowoff_n[9]}
N 3370 -6250 3380 -6240 {lab=rowoff_n[9]}
N 3380 -6240 3510 -6240 {lab=rowoff_n[9]}
N 3160 -6220 3170 -6230 {lab=row_n[9]}
N 3170 -6230 3370 -6230 {lab=row_n[9]}
N 3370 -6230 3380 -6220 {lab=row_n[9]}
N 3380 -6220 3510 -6220 {lab=row_n[9]}
N 3160 -6200 3170 -6210 {lab=rowon_n[9]}
N 3170 -6210 3370 -6210 {lab=rowon_n[9]}
N 3370 -6210 3380 -6200 {lab=rowon_n[9]}
N 3380 -6200 3510 -6200 {lab=rowon_n[9]}
N 3370 -6190 3380 -6180 {lab=#net17}
N 3380 -6180 3510 -6180 {lab=#net17}
N 3160 -6160 3170 -6170 {lab=#net18}
N 3170 -6170 3370 -6170 {lab=#net18}
N 3370 -6170 3380 -6160 {lab=#net18}
N 3380 -6160 3510 -6160 {lab=#net18}
N 3160 -6180 3170 -6190 {lab=#net17}
N 3170 -6190 3370 -6190 {lab=#net17}
N 3510 -6240 3520 -6250 {lab=rowoff_n[9]}
N 3520 -6250 3720 -6250 {lab=rowoff_n[9]}
N 3720 -6250 3730 -6240 {lab=rowoff_n[9]}
N 3730 -6240 3850 -6240 {lab=rowoff_n[9]}
N 3510 -6220 3520 -6230 {lab=row_n[9]}
N 3520 -6230 3720 -6230 {lab=row_n[9]}
N 3720 -6230 3730 -6220 {lab=row_n[9]}
N 3730 -6220 3850 -6220 {lab=row_n[9]}
N 3510 -6200 3520 -6210 {lab=rowon_n[9]}
N 3520 -6210 3720 -6210 {lab=rowon_n[9]}
N 3720 -6210 3730 -6200 {lab=rowon_n[9]}
N 3730 -6200 3850 -6200 {lab=rowon_n[9]}
N 3510 -6180 3520 -6190 {lab=#net17}
N 3520 -6190 3720 -6190 {lab=#net17}
N 3720 -6190 3730 -6180 {lab=#net17}
N 3730 -6180 3850 -6180 {lab=#net17}
N 3510 -6160 3520 -6170 {lab=#net18}
N 3520 -6170 3720 -6170 {lab=#net18}
N 3720 -6170 3730 -6160 {lab=#net18}
N 3730 -6160 3850 -6160 {lab=#net18}
N 3850 -6240 3860 -6250 {lab=rowoff_n[9]}
N 3860 -6250 4060 -6250 {lab=rowoff_n[9]}
N 4060 -6250 4070 -6240 {lab=rowoff_n[9]}
N 4070 -6240 4200 -6240 {lab=rowoff_n[9]}
N 3850 -6220 3860 -6230 {lab=row_n[9]}
N 3860 -6230 4060 -6230 {lab=row_n[9]}
N 4060 -6230 4070 -6220 {lab=row_n[9]}
N 4070 -6220 4200 -6220 {lab=row_n[9]}
N 3850 -6200 3860 -6210 {lab=rowon_n[9]}
N 3860 -6210 4060 -6210 {lab=rowon_n[9]}
N 4060 -6210 4070 -6200 {lab=rowon_n[9]}
N 4070 -6200 4200 -6200 {lab=rowon_n[9]}
N 3850 -6180 3860 -6190 {lab=#net17}
N 3860 -6190 4060 -6190 {lab=#net17}
N 3850 -6160 3860 -6170 {lab=#net18}
N 3860 -6170 4060 -6170 {lab=#net18}
N 4060 -6170 4070 -6160 {lab=#net18}
N 4070 -6160 4200 -6160 {lab=#net18}
N 4060 -6190 4070 -6180 {lab=#net17}
N 4070 -6180 4200 -6180 {lab=#net17}
N 4200 -6240 4210 -6250 {lab=rowoff_n[9]}
N 4210 -6250 4410 -6250 {lab=rowoff_n[9]}
N 4410 -6250 4420 -6240 {lab=rowoff_n[9]}
N 4420 -6240 4560 -6240 {lab=rowoff_n[9]}
N 4200 -6220 4210 -6230 {lab=row_n[9]}
N 4210 -6230 4410 -6230 {lab=row_n[9]}
N 4410 -6230 4420 -6220 {lab=row_n[9]}
N 4420 -6220 4560 -6220 {lab=row_n[9]}
N 4200 -6200 4210 -6210 {lab=rowon_n[9]}
N 4210 -6210 4410 -6210 {lab=rowon_n[9]}
N 4410 -6210 4420 -6200 {lab=rowon_n[9]}
N 4420 -6200 4560 -6200 {lab=rowon_n[9]}
N 4200 -6180 4210 -6190 {lab=#net17}
N 4210 -6190 4410 -6190 {lab=#net17}
N 4410 -6190 4420 -6180 {lab=#net17}
N 4420 -6180 4560 -6180 {lab=#net17}
N 4200 -6160 4210 -6170 {lab=#net18}
N 4210 -6170 4410 -6170 {lab=#net18}
N 4410 -6170 4420 -6160 {lab=#net18}
N 4420 -6160 4560 -6160 {lab=#net18}
N 4560 -6240 4570 -6250 {lab=rowoff_n[9]}
N 4570 -6250 4770 -6250 {lab=rowoff_n[9]}
N 4770 -6250 4780 -6240 {lab=rowoff_n[9]}
N 4780 -6240 4890 -6240 {lab=rowoff_n[9]}
N 4560 -6220 4570 -6230 {lab=row_n[9]}
N 4570 -6230 4770 -6230 {lab=row_n[9]}
N 4770 -6230 4780 -6220 {lab=row_n[9]}
N 4780 -6220 4890 -6220 {lab=row_n[9]}
N 4560 -6200 4570 -6210 {lab=rowon_n[9]}
N 4570 -6210 4770 -6210 {lab=rowon_n[9]}
N 4770 -6210 4780 -6200 {lab=rowon_n[9]}
N 4780 -6200 4890 -6200 {lab=rowon_n[9]}
N 4560 -6180 4570 -6190 {lab=#net17}
N 4570 -6190 4770 -6190 {lab=#net17}
N 4770 -6190 4780 -6180 {lab=#net17}
N 4780 -6180 4890 -6180 {lab=#net17}
N 4560 -6160 4570 -6170 {lab=#net18}
N 4570 -6170 4770 -6170 {lab=#net18}
N 4770 -6170 4780 -6160 {lab=#net18}
N 4780 -6160 4890 -6160 {lab=#net18}
N 4890 -6240 4900 -6250 {lab=rowoff_n[9]}
N 4900 -6250 5100 -6250 {lab=rowoff_n[9]}
N 5100 -6250 5110 -6240 {lab=rowoff_n[9]}
N 5110 -6240 5220 -6240 {lab=rowoff_n[9]}
N 4890 -6220 4900 -6230 {lab=row_n[9]}
N 4900 -6230 5100 -6230 {lab=row_n[9]}
N 5100 -6230 5110 -6220 {lab=row_n[9]}
N 5110 -6220 5220 -6220 {lab=row_n[9]}
N 4890 -6200 4900 -6210 {lab=rowon_n[9]}
N 4900 -6210 5100 -6210 {lab=rowon_n[9]}
N 5100 -6210 5110 -6200 {lab=rowon_n[9]}
N 5110 -6200 5220 -6200 {lab=rowon_n[9]}
N 4890 -6180 4900 -6190 {lab=#net17}
N 4900 -6190 5100 -6190 {lab=#net17}
N 5100 -6190 5110 -6180 {lab=#net17}
N 5110 -6180 5220 -6180 {lab=#net17}
N 4890 -6160 4900 -6170 {lab=#net18}
N 4900 -6170 5100 -6170 {lab=#net18}
N 5100 -6170 5120 -6160 {lab=#net18}
N 5120 -6160 5220 -6160 {lab=#net18}
N 5220 -6240 5230 -6250 {lab=rowoff_n[9]}
N 5230 -6250 5430 -6250 {lab=rowoff_n[9]}
N 5430 -6250 5440 -6240 {lab=rowoff_n[9]}
N 5440 -6240 5570 -6240 {lab=rowoff_n[9]}
N 5220 -6220 5230 -6230 {lab=row_n[9]}
N 5230 -6230 5430 -6230 {lab=row_n[9]}
N 5430 -6230 5440 -6220 {lab=row_n[9]}
N 5440 -6220 5570 -6220 {lab=row_n[9]}
N 5220 -6200 5230 -6210 {lab=rowon_n[9]}
N 5230 -6210 5430 -6210 {lab=rowon_n[9]}
N 5430 -6210 5440 -6200 {lab=rowon_n[9]}
N 5440 -6200 5570 -6200 {lab=rowon_n[9]}
N 5220 -6180 5230 -6190 {lab=#net17}
N 5230 -6190 5430 -6190 {lab=#net17}
N 5430 -6190 5440 -6180 {lab=#net17}
N 5440 -6180 5570 -6180 {lab=#net17}
N 5220 -6160 5230 -6170 {lab=#net18}
N 5230 -6170 5430 -6170 {lab=#net18}
N 5430 -6170 5440 -6160 {lab=#net18}
N 5440 -6160 5570 -6160 {lab=#net18}
N 5570 -6240 5580 -6250 {lab=rowoff_n[9]}
N 5580 -6250 5780 -6250 {lab=rowoff_n[9]}
N 5780 -6250 5790 -6240 {lab=rowoff_n[9]}
N 5790 -6240 5920 -6240 {lab=rowoff_n[9]}
N 5570 -6220 5580 -6230 {lab=row_n[9]}
N 5580 -6230 5780 -6230 {lab=row_n[9]}
N 5570 -6200 5580 -6210 {lab=rowon_n[9]}
N 5580 -6210 5780 -6210 {lab=rowon_n[9]}
N 5780 -6210 5790 -6200 {lab=rowon_n[9]}
N 5790 -6200 5920 -6200 {lab=rowon_n[9]}
N 5780 -6230 5790 -6220 {lab=row_n[9]}
N 5790 -6220 5920 -6220 {lab=row_n[9]}
N 5570 -6180 5580 -6190 {lab=#net17}
N 5580 -6190 5780 -6190 {lab=#net17}
N 5780 -6190 5790 -6180 {lab=#net17}
N 5790 -6180 5920 -6180 {lab=#net17}
N 5570 -6160 5580 -6170 {lab=#net18}
N 5580 -6170 5780 -6170 {lab=#net18}
N 5780 -6170 5790 -6160 {lab=#net18}
N 5790 -6160 5920 -6160 {lab=#net18}
N 5920 -6240 5930 -6250 {lab=rowoff_n[9]}
N 5930 -6250 6130 -6250 {lab=rowoff_n[9]}
N 6130 -6250 6140 -6240 {lab=rowoff_n[9]}
N 6140 -6240 6260 -6240 {lab=rowoff_n[9]}
N 5920 -6220 5930 -6230 {lab=row_n[9]}
N 5930 -6230 6130 -6230 {lab=row_n[9]}
N 6130 -6230 6140 -6220 {lab=row_n[9]}
N 6140 -6220 6260 -6220 {lab=row_n[9]}
N 5920 -6200 5930 -6210 {lab=rowon_n[9]}
N 5930 -6210 6130 -6210 {lab=rowon_n[9]}
N 6130 -6210 6140 -6200 {lab=rowon_n[9]}
N 6140 -6200 6260 -6200 {lab=rowon_n[9]}
N 5920 -6180 5930 -6190 {lab=#net17}
N 5930 -6190 6130 -6190 {lab=#net17}
N 6130 -6190 6140 -6180 {lab=#net17}
N 6140 -6180 6260 -6180 {lab=#net17}
N 5920 -6160 5930 -6170 {lab=#net18}
N 5930 -6170 6130 -6170 {lab=#net18}
N 6130 -6170 6140 -6160 {lab=#net18}
N 6140 -6160 6260 -6160 {lab=#net18}
N 6260 -6240 6270 -6250 {lab=rowoff_n[9]}
N 6270 -6250 6470 -6250 {lab=rowoff_n[9]}
N 6470 -6250 6480 -6240 {lab=rowoff_n[9]}
N 6480 -6240 6600 -6240 {lab=rowoff_n[9]}
N 6260 -6220 6270 -6230 {lab=row_n[9]}
N 6270 -6230 6470 -6230 {lab=row_n[9]}
N 6470 -6230 6480 -6220 {lab=row_n[9]}
N 6480 -6220 6600 -6220 {lab=row_n[9]}
N 6260 -6200 6270 -6210 {lab=rowon_n[9]}
N 6270 -6210 6470 -6210 {lab=rowon_n[9]}
N 6470 -6210 6480 -6200 {lab=rowon_n[9]}
N 6480 -6200 6600 -6200 {lab=rowon_n[9]}
N 6260 -6180 6270 -6190 {lab=#net17}
N 6270 -6190 6470 -6190 {lab=#net17}
N 6470 -6190 6480 -6180 {lab=#net17}
N 6480 -6180 6600 -6180 {lab=#net17}
N 6260 -6160 6270 -6170 {lab=#net18}
N 6270 -6170 6470 -6170 {lab=#net18}
N 6470 -6170 6490 -6160 {lab=#net18}
N 6490 -6160 6600 -6160 {lab=#net18}
N 6600 -6240 6610 -6250 {lab=rowoff_n[9]}
N 6610 -6250 6810 -6250 {lab=rowoff_n[9]}
N 6600 -6220 6610 -6230 {lab=row_n[9]}
N 6610 -6230 6810 -6230 {lab=row_n[9]}
N 6810 -6230 6820 -6220 {lab=row_n[9]}
N 6810 -6250 6820 -6240 {lab=rowoff_n[9]}
N 6600 -6200 6610 -6210 {lab=rowon_n[9]}
N 6610 -6210 6810 -6210 {lab=rowon_n[9]}
N 6600 -6180 6610 -6190 {lab=#net17}
N 6610 -6190 6810 -6190 {lab=#net17}
N 6810 -6190 6820 -6180 {lab=#net17}
N 6600 -6160 6610 -6170 {lab=#net18}
N 6610 -6170 6810 -6170 {lab=#net18}
N 6810 -6170 6820 -6160 {lab=#net18}
N 6810 -6210 6820 -6200 {lab=rowon_n[9]}
N 1850 -6410 1850 -6400 {
lab=VSS}
N 2170 -6410 2170 -6400 {
lab=VSS}
N 2500 -6410 2500 -6400 {
lab=VSS}
N 2850 -6410 2850 -6400 {
lab=VSS}
N 3200 -6410 3200 -6400 {
lab=VSS}
N 3550 -6410 3550 -6400 {
lab=VSS}
N 3890 -6410 3890 -6400 {
lab=VSS}
N 4240 -6410 4240 -6400 {
lab=VSS}
N 4600 -6410 4600 -6400 {
lab=VSS}
N 4930 -6410 4930 -6400 {
lab=VSS}
N 5260 -6410 5260 -6400 {
lab=VSS}
N 5610 -6410 5610 -6400 {
lab=VSS}
N 5960 -6410 5960 -6400 {
lab=VSS}
N 6300 -6410 6300 -6400 {
lab=VSS}
N 6640 -6410 6640 -6400 {
lab=VSS}
N 6660 -6650 6660 -6630 {
lab=vcm}
N 6640 -6640 6640 -6630 {
lab=VDD}
N 6700 -6650 6700 -6630 {
lab=ctop}
N 5980 -6650 5980 -6630 {
lab=vcm}
N 5960 -6640 5960 -6630 {
lab=VDD}
N 6020 -6650 6020 -6630 {
lab=ctop}
N 6320 -6650 6320 -6630 {
lab=vcm}
N 6300 -6640 6300 -6630 {
lab=VDD}
N 6360 -6650 6360 -6630 {
lab=ctop}
N 5630 -6650 5630 -6630 {
lab=vcm}
N 5610 -6640 5610 -6630 {
lab=VDD}
N 5670 -6650 5670 -6630 {
lab=ctop}
N 5280 -6650 5280 -6630 {
lab=vcm}
N 5260 -6640 5260 -6630 {
lab=VDD}
N 5320 -6650 5320 -6630 {
lab=ctop}
N 4950 -6650 4950 -6630 {
lab=vcm}
N 4930 -6640 4930 -6630 {
lab=VDD}
N 4990 -6650 4990 -6630 {
lab=ctop}
N 4620 -6650 4620 -6630 {
lab=vcm}
N 4600 -6640 4600 -6630 {
lab=VDD}
N 4660 -6650 4660 -6630 {
lab=ctop}
N 4260 -6650 4260 -6630 {
lab=vcm}
N 4240 -6640 4240 -6630 {
lab=VDD}
N 4300 -6650 4300 -6630 {
lab=ctop}
N 3910 -6650 3910 -6630 {
lab=vcm}
N 3890 -6640 3890 -6630 {
lab=VDD}
N 3950 -6650 3950 -6630 {
lab=ctop}
N 3570 -6650 3570 -6630 {
lab=vcm}
N 3550 -6640 3550 -6630 {
lab=VDD}
N 3610 -6650 3610 -6630 {
lab=ctop}
N 3220 -6650 3220 -6630 {
lab=vcm}
N 3200 -6640 3200 -6630 {
lab=VDD}
N 3260 -6650 3260 -6630 {
lab=ctop}
N 2870 -6650 2870 -6630 {
lab=vcm}
N 2850 -6640 2850 -6630 {
lab=VDD}
N 2910 -6650 2910 -6630 {
lab=ctop}
N 2520 -6650 2520 -6630 {
lab=vcm}
N 2500 -6640 2500 -6630 {
lab=VDD}
N 2560 -6650 2560 -6630 {
lab=ctop}
N 2190 -6650 2190 -6630 {
lab=vcm}
N 2170 -6640 2170 -6630 {
lab=VDD}
N 2230 -6650 2230 -6630 {
lab=ctop}
N 1870 -6650 1870 -6630 {
lab=vcm}
N 1850 -6640 1850 -6630 {
lab=VDD}
N 1910 -6650 1910 -6630 {
lab=ctop}
N 1790 -6490 1810 -6490 {
lab=sample_n}
N 1790 -6510 1810 -6510 {
lab=sample}
N 1790 -6530 1810 -6530 {
lab=VDD}
N 1790 -6550 1810 -6550 {
lab=VDD}
N 1790 -6570 1810 -6570 {
lab=VSS}
N 2030 -6510 2130 -6510 {lab=#net19}
N 2030 -6490 2130 -6490 {lab=#net20}
N 1810 -6570 1820 -6580 {lab=VSS}
N 1820 -6580 2040 -6580 {lab=VSS}
N 2040 -6580 2050 -6570 {lab=VSS}
N 2050 -6570 2130 -6570 {lab=VSS}
N 1810 -6550 1820 -6560 {lab=VDD}
N 1820 -6560 2040 -6560 {lab=VDD}
N 2040 -6560 2050 -6550 {lab=VDD}
N 2050 -6550 2130 -6550 {lab=VDD}
N 1810 -6530 1820 -6540 {lab=VDD}
N 1820 -6540 2040 -6540 {lab=VDD}
N 2040 -6540 2050 -6530 {lab=VDD}
N 2050 -6530 2130 -6530 {lab=VDD}
N 2130 -6570 2140 -6580 {lab=VSS}
N 2130 -6550 2140 -6560 {lab=VDD}
N 2140 -6560 2340 -6560 {lab=VDD}
N 2340 -6560 2350 -6550 {lab=VDD}
N 2350 -6550 2460 -6550 {lab=VDD}
N 2140 -6580 2340 -6580 {lab=VSS}
N 2340 -6580 2350 -6570 {lab=VSS}
N 2350 -6570 2460 -6570 {lab=VSS}
N 2130 -6530 2140 -6540 {lab=VDD}
N 2140 -6540 2340 -6540 {lab=VDD}
N 2340 -6540 2350 -6530 {lab=VDD}
N 2350 -6530 2460 -6530 {lab=VDD}
N 2130 -6510 2140 -6520 {lab=#net19}
N 2140 -6520 2340 -6520 {lab=#net19}
N 2340 -6520 2350 -6510 {lab=#net19}
N 2350 -6510 2460 -6510 {lab=#net19}
N 2130 -6490 2140 -6500 {lab=#net20}
N 2140 -6500 2340 -6500 {lab=#net20}
N 2340 -6500 2350 -6490 {lab=#net20}
N 2350 -6490 2460 -6490 {lab=#net20}
N 2460 -6550 2470 -6560 {lab=VDD}
N 2470 -6560 2670 -6560 {lab=VDD}
N 2670 -6560 2680 -6550 {lab=VDD}
N 2680 -6550 2810 -6550 {lab=VDD}
N 2460 -6530 2470 -6540 {lab=VDD}
N 2470 -6540 2670 -6540 {lab=VDD}
N 2670 -6540 2680 -6530 {lab=VDD}
N 2680 -6530 2810 -6530 {lab=VDD}
N 2460 -6510 2470 -6520 {lab=#net19}
N 2470 -6520 2670 -6520 {lab=#net19}
N 2670 -6520 2680 -6510 {lab=#net19}
N 2680 -6510 2810 -6510 {lab=#net19}
N 2460 -6490 2480 -6500 {lab=#net20}
N 2480 -6500 2670 -6500 {lab=#net20}
N 2670 -6500 2680 -6490 {lab=#net20}
N 2680 -6490 2810 -6490 {lab=#net20}
N 2460 -6570 2470 -6580 {lab=VSS}
N 2470 -6580 2670 -6580 {lab=VSS}
N 2670 -6580 2680 -6570 {lab=VSS}
N 2680 -6570 2810 -6570 {lab=VSS}
N 2810 -6570 2820 -6580 {lab=VSS}
N 2820 -6580 3020 -6580 {lab=VSS}
N 3020 -6580 3030 -6570 {lab=VSS}
N 3030 -6570 3160 -6570 {lab=VSS}
N 2810 -6550 2820 -6560 {lab=VDD}
N 2820 -6560 3020 -6560 {lab=VDD}
N 3020 -6560 3030 -6550 {lab=VDD}
N 3030 -6550 3160 -6550 {lab=VDD}
N 2810 -6530 2820 -6540 {lab=VDD}
N 2820 -6540 3020 -6540 {lab=VDD}
N 3020 -6540 3030 -6530 {lab=VDD}
N 3030 -6530 3160 -6530 {lab=VDD}
N 2810 -6510 2820 -6520 {lab=#net19}
N 2820 -6520 3020 -6520 {lab=#net19}
N 3020 -6520 3030 -6510 {lab=#net19}
N 3030 -6510 3160 -6510 {lab=#net19}
N 2810 -6490 2820 -6500 {lab=#net20}
N 2820 -6500 3020 -6500 {lab=#net20}
N 3020 -6500 3030 -6490 {lab=#net20}
N 3030 -6490 3160 -6490 {lab=#net20}
N 3160 -6570 3170 -6580 {lab=VSS}
N 3170 -6580 3370 -6580 {lab=VSS}
N 3370 -6580 3380 -6570 {lab=VSS}
N 3380 -6570 3510 -6570 {lab=VSS}
N 3160 -6550 3170 -6560 {lab=VDD}
N 3170 -6560 3370 -6560 {lab=VDD}
N 3370 -6560 3380 -6550 {lab=VDD}
N 3380 -6550 3510 -6550 {lab=VDD}
N 3160 -6530 3170 -6540 {lab=VDD}
N 3170 -6540 3370 -6540 {lab=VDD}
N 3370 -6540 3380 -6530 {lab=VDD}
N 3380 -6530 3510 -6530 {lab=VDD}
N 3370 -6520 3380 -6510 {lab=#net19}
N 3380 -6510 3510 -6510 {lab=#net19}
N 3160 -6490 3170 -6500 {lab=#net20}
N 3170 -6500 3370 -6500 {lab=#net20}
N 3370 -6500 3380 -6490 {lab=#net20}
N 3380 -6490 3510 -6490 {lab=#net20}
N 3160 -6510 3170 -6520 {lab=#net19}
N 3170 -6520 3370 -6520 {lab=#net19}
N 3510 -6570 3520 -6580 {lab=VSS}
N 3520 -6580 3720 -6580 {lab=VSS}
N 3720 -6580 3730 -6570 {lab=VSS}
N 3730 -6570 3850 -6570 {lab=VSS}
N 3510 -6550 3520 -6560 {lab=VDD}
N 3520 -6560 3720 -6560 {lab=VDD}
N 3720 -6560 3730 -6550 {lab=VDD}
N 3730 -6550 3850 -6550 {lab=VDD}
N 3510 -6530 3520 -6540 {lab=VDD}
N 3520 -6540 3720 -6540 {lab=VDD}
N 3720 -6540 3730 -6530 {lab=VDD}
N 3730 -6530 3850 -6530 {lab=VDD}
N 3510 -6510 3520 -6520 {lab=#net19}
N 3520 -6520 3720 -6520 {lab=#net19}
N 3720 -6520 3730 -6510 {lab=#net19}
N 3730 -6510 3850 -6510 {lab=#net19}
N 3510 -6490 3520 -6500 {lab=#net20}
N 3520 -6500 3720 -6500 {lab=#net20}
N 3720 -6500 3730 -6490 {lab=#net20}
N 3730 -6490 3850 -6490 {lab=#net20}
N 3850 -6570 3860 -6580 {lab=VSS}
N 3860 -6580 4060 -6580 {lab=VSS}
N 4060 -6580 4070 -6570 {lab=VSS}
N 4070 -6570 4200 -6570 {lab=VSS}
N 3850 -6550 3860 -6560 {lab=VDD}
N 3860 -6560 4060 -6560 {lab=VDD}
N 4060 -6560 4070 -6550 {lab=VDD}
N 4070 -6550 4200 -6550 {lab=VDD}
N 3850 -6530 3860 -6540 {lab=VDD}
N 3860 -6540 4060 -6540 {lab=VDD}
N 4060 -6540 4070 -6530 {lab=VDD}
N 4070 -6530 4200 -6530 {lab=VDD}
N 3850 -6510 3860 -6520 {lab=#net19}
N 3860 -6520 4060 -6520 {lab=#net19}
N 3850 -6490 3860 -6500 {lab=#net20}
N 3860 -6500 4060 -6500 {lab=#net20}
N 4060 -6500 4070 -6490 {lab=#net20}
N 4070 -6490 4200 -6490 {lab=#net20}
N 4060 -6520 4070 -6510 {lab=#net19}
N 4070 -6510 4200 -6510 {lab=#net19}
N 4200 -6570 4210 -6580 {lab=VSS}
N 4210 -6580 4410 -6580 {lab=VSS}
N 4410 -6580 4420 -6570 {lab=VSS}
N 4420 -6570 4560 -6570 {lab=VSS}
N 4200 -6550 4210 -6560 {lab=VDD}
N 4210 -6560 4410 -6560 {lab=VDD}
N 4410 -6560 4420 -6550 {lab=VDD}
N 4420 -6550 4560 -6550 {lab=VDD}
N 4200 -6530 4210 -6540 {lab=VDD}
N 4210 -6540 4410 -6540 {lab=VDD}
N 4410 -6540 4420 -6530 {lab=VDD}
N 4420 -6530 4560 -6530 {lab=VDD}
N 4200 -6510 4210 -6520 {lab=#net19}
N 4210 -6520 4410 -6520 {lab=#net19}
N 4410 -6520 4420 -6510 {lab=#net19}
N 4420 -6510 4560 -6510 {lab=#net19}
N 4200 -6490 4210 -6500 {lab=#net20}
N 4210 -6500 4410 -6500 {lab=#net20}
N 4410 -6500 4420 -6490 {lab=#net20}
N 4420 -6490 4560 -6490 {lab=#net20}
N 4560 -6570 4570 -6580 {lab=VSS}
N 4570 -6580 4770 -6580 {lab=VSS}
N 4770 -6580 4780 -6570 {lab=VSS}
N 4780 -6570 4890 -6570 {lab=VSS}
N 4560 -6550 4570 -6560 {lab=VDD}
N 4570 -6560 4770 -6560 {lab=VDD}
N 4770 -6560 4780 -6550 {lab=VDD}
N 4780 -6550 4890 -6550 {lab=VDD}
N 4560 -6530 4570 -6540 {lab=VDD}
N 4570 -6540 4770 -6540 {lab=VDD}
N 4770 -6540 4780 -6530 {lab=VDD}
N 4780 -6530 4890 -6530 {lab=VDD}
N 4560 -6510 4570 -6520 {lab=#net19}
N 4570 -6520 4770 -6520 {lab=#net19}
N 4770 -6520 4780 -6510 {lab=#net19}
N 4780 -6510 4890 -6510 {lab=#net19}
N 4560 -6490 4570 -6500 {lab=#net20}
N 4570 -6500 4770 -6500 {lab=#net20}
N 4770 -6500 4780 -6490 {lab=#net20}
N 4780 -6490 4890 -6490 {lab=#net20}
N 4890 -6570 4900 -6580 {lab=VSS}
N 4900 -6580 5100 -6580 {lab=VSS}
N 5100 -6580 5110 -6570 {lab=VSS}
N 5110 -6570 5220 -6570 {lab=VSS}
N 4890 -6550 4900 -6560 {lab=VDD}
N 4900 -6560 5100 -6560 {lab=VDD}
N 5100 -6560 5110 -6550 {lab=VDD}
N 5110 -6550 5220 -6550 {lab=VDD}
N 4890 -6530 4900 -6540 {lab=VDD}
N 4900 -6540 5100 -6540 {lab=VDD}
N 5100 -6540 5110 -6530 {lab=VDD}
N 5110 -6530 5220 -6530 {lab=VDD}
N 4890 -6510 4900 -6520 {lab=#net19}
N 4900 -6520 5100 -6520 {lab=#net19}
N 5100 -6520 5110 -6510 {lab=#net19}
N 5110 -6510 5220 -6510 {lab=#net19}
N 4890 -6490 4900 -6500 {lab=#net20}
N 4900 -6500 5100 -6500 {lab=#net20}
N 5100 -6500 5120 -6490 {lab=#net20}
N 5120 -6490 5220 -6490 {lab=#net20}
N 5220 -6570 5230 -6580 {lab=VSS}
N 5230 -6580 5430 -6580 {lab=VSS}
N 5430 -6580 5440 -6570 {lab=VSS}
N 5440 -6570 5570 -6570 {lab=VSS}
N 5220 -6550 5230 -6560 {lab=VDD}
N 5230 -6560 5430 -6560 {lab=VDD}
N 5430 -6560 5440 -6550 {lab=VDD}
N 5440 -6550 5570 -6550 {lab=VDD}
N 5220 -6530 5230 -6540 {lab=VDD}
N 5230 -6540 5430 -6540 {lab=VDD}
N 5430 -6540 5440 -6530 {lab=VDD}
N 5440 -6530 5570 -6530 {lab=VDD}
N 5220 -6510 5230 -6520 {lab=#net19}
N 5230 -6520 5430 -6520 {lab=#net19}
N 5430 -6520 5440 -6510 {lab=#net19}
N 5440 -6510 5570 -6510 {lab=#net19}
N 5220 -6490 5230 -6500 {lab=#net20}
N 5230 -6500 5430 -6500 {lab=#net20}
N 5430 -6500 5440 -6490 {lab=#net20}
N 5440 -6490 5570 -6490 {lab=#net20}
N 5570 -6570 5580 -6580 {lab=VSS}
N 5580 -6580 5780 -6580 {lab=VSS}
N 5780 -6580 5790 -6570 {lab=VSS}
N 5790 -6570 5920 -6570 {lab=VSS}
N 5570 -6550 5580 -6560 {lab=VDD}
N 5580 -6560 5780 -6560 {lab=VDD}
N 5570 -6530 5580 -6540 {lab=VDD}
N 5580 -6540 5780 -6540 {lab=VDD}
N 5780 -6540 5790 -6530 {lab=VDD}
N 5790 -6530 5920 -6530 {lab=VDD}
N 5780 -6560 5790 -6550 {lab=VDD}
N 5790 -6550 5920 -6550 {lab=VDD}
N 5570 -6510 5580 -6520 {lab=#net19}
N 5580 -6520 5780 -6520 {lab=#net19}
N 5780 -6520 5790 -6510 {lab=#net19}
N 5790 -6510 5920 -6510 {lab=#net19}
N 5570 -6490 5580 -6500 {lab=#net20}
N 5580 -6500 5780 -6500 {lab=#net20}
N 5780 -6500 5790 -6490 {lab=#net20}
N 5790 -6490 5920 -6490 {lab=#net20}
N 5920 -6570 5930 -6580 {lab=VSS}
N 5930 -6580 6130 -6580 {lab=VSS}
N 6130 -6580 6140 -6570 {lab=VSS}
N 6140 -6570 6260 -6570 {lab=VSS}
N 5920 -6550 5930 -6560 {lab=VDD}
N 5930 -6560 6130 -6560 {lab=VDD}
N 6130 -6560 6140 -6550 {lab=VDD}
N 6140 -6550 6260 -6550 {lab=VDD}
N 5920 -6530 5930 -6540 {lab=VDD}
N 5930 -6540 6130 -6540 {lab=VDD}
N 6130 -6540 6140 -6530 {lab=VDD}
N 6140 -6530 6260 -6530 {lab=VDD}
N 5920 -6510 5930 -6520 {lab=#net19}
N 5930 -6520 6130 -6520 {lab=#net19}
N 6130 -6520 6140 -6510 {lab=#net19}
N 6140 -6510 6260 -6510 {lab=#net19}
N 5920 -6490 5930 -6500 {lab=#net20}
N 5930 -6500 6130 -6500 {lab=#net20}
N 6130 -6500 6140 -6490 {lab=#net20}
N 6140 -6490 6260 -6490 {lab=#net20}
N 6260 -6570 6270 -6580 {lab=VSS}
N 6270 -6580 6470 -6580 {lab=VSS}
N 6470 -6580 6480 -6570 {lab=VSS}
N 6480 -6570 6600 -6570 {lab=VSS}
N 6260 -6550 6270 -6560 {lab=VDD}
N 6270 -6560 6470 -6560 {lab=VDD}
N 6470 -6560 6480 -6550 {lab=VDD}
N 6480 -6550 6600 -6550 {lab=VDD}
N 6260 -6530 6270 -6540 {lab=VDD}
N 6270 -6540 6470 -6540 {lab=VDD}
N 6470 -6540 6480 -6530 {lab=VDD}
N 6480 -6530 6600 -6530 {lab=VDD}
N 6260 -6510 6270 -6520 {lab=#net19}
N 6270 -6520 6470 -6520 {lab=#net19}
N 6470 -6520 6480 -6510 {lab=#net19}
N 6480 -6510 6600 -6510 {lab=#net19}
N 6260 -6490 6270 -6500 {lab=#net20}
N 6270 -6500 6470 -6500 {lab=#net20}
N 6470 -6500 6490 -6490 {lab=#net20}
N 6490 -6490 6600 -6490 {lab=#net20}
N 6600 -6570 6610 -6580 {lab=VSS}
N 6610 -6580 6810 -6580 {lab=VSS}
N 6600 -6550 6610 -6560 {lab=VDD}
N 6610 -6560 6810 -6560 {lab=VDD}
N 6810 -6560 6820 -6550 {lab=VDD}
N 6810 -6580 6820 -6570 {lab=VSS}
N 6600 -6530 6610 -6540 {lab=VDD}
N 6610 -6540 6810 -6540 {lab=VDD}
N 6600 -6510 6610 -6520 {lab=#net19}
N 6610 -6520 6810 -6520 {lab=#net19}
N 6810 -6520 6820 -6510 {lab=#net19}
N 6600 -6490 6610 -6500 {lab=#net20}
N 6610 -6500 6810 -6500 {lab=#net20}
N 6810 -6500 6820 -6490 {lab=#net20}
N 6810 -6540 6820 -6530 {lab=VDD}
N 1930 -6080 1940 -6090 {lab=VDD}
N 1940 -6340 1940 -6090 {lab=VDD}
N 1930 -6350 1940 -6340 {lab=VDD}
N 1930 -6410 1930 -6350 {lab=VDD}
N 1950 -6410 1950 -6350 {lab=VSS}
N 1950 -6350 1960 -6340 {lab=VSS}
N 1960 -6340 1960 -6090 {lab=VSS}
N 1950 -6080 1960 -6090 {lab=VSS}
N 2260 -6340 2260 -6090 {lab=col_n[0]}
N 2250 -6350 2260 -6340 {lab=col_n[0]}
N 2250 -6410 2250 -6350 {lab=col_n[0]}
N 2270 -6410 2270 -6350 {lab=col[0]}
N 2270 -6350 2280 -6340 {lab=col[0]}
N 2280 -6340 2280 -6090 {lab=col[0]}
N 2590 -6340 2590 -6090 {lab=col_n[1]}
N 2580 -6350 2590 -6340 {lab=col_n[1]}
N 2580 -6410 2580 -6350 {lab=col_n[1]}
N 2600 -6410 2600 -6350 {lab=col[1]}
N 2600 -6350 2610 -6340 {lab=col[1]}
N 2610 -6340 2610 -6090 {lab=col[1]}
N 2940 -6340 2940 -6090 {lab=col_n[2]}
N 2930 -6350 2940 -6340 {lab=col_n[2]}
N 2930 -6410 2930 -6350 {lab=col_n[2]}
N 2950 -6410 2950 -6350 {lab=col[2]}
N 2950 -6350 2960 -6340 {lab=col[2]}
N 2960 -6340 2960 -6090 {lab=col[2]}
N 3290 -6340 3290 -6090 {lab=col_n[3]}
N 3280 -6350 3290 -6340 {lab=col_n[3]}
N 3280 -6410 3280 -6350 {lab=col_n[3]}
N 3300 -6410 3300 -6350 {lab=col[3]}
N 3300 -6350 3310 -6340 {lab=col[3]}
N 3310 -6340 3310 -6090 {lab=col[3]}
N 3640 -6340 3640 -6090 {lab=col_n[4]}
N 3630 -6350 3640 -6340 {lab=col_n[4]}
N 3630 -6410 3630 -6350 {lab=col_n[4]}
N 3650 -6410 3650 -6350 {lab=col[4]}
N 3650 -6350 3660 -6340 {lab=col[4]}
N 3660 -6340 3660 -6090 {lab=col[4]}
N 3980 -6340 3980 -6090 {lab=col_n[5]}
N 3970 -6350 3980 -6340 {lab=col_n[5]}
N 3970 -6410 3970 -6350 {lab=col_n[5]}
N 3990 -6410 3990 -6350 {lab=col[5]}
N 3990 -6350 4000 -6340 {lab=col[5]}
N 4000 -6340 4000 -6090 {lab=col[5]}
N 4330 -6340 4330 -6090 {lab=col_n[6]}
N 4320 -6350 4330 -6340 {lab=col_n[6]}
N 4320 -6410 4320 -6350 {lab=col_n[6]}
N 4340 -6410 4340 -6350 {lab=col[6]}
N 4340 -6350 4350 -6340 {lab=col[6]}
N 4350 -6340 4350 -6090 {lab=col[6]}
N 4690 -6340 4690 -6090 {lab=col_n[7]}
N 4680 -6350 4690 -6340 {lab=col_n[7]}
N 4680 -6410 4680 -6350 {lab=col_n[7]}
N 4700 -6410 4700 -6350 {lab=col[7]}
N 4700 -6350 4710 -6340 {lab=col[7]}
N 4710 -6340 4710 -6090 {lab=col[7]}
N 5020 -6340 5020 -6090 {lab=col_n[8]}
N 5010 -6350 5020 -6340 {lab=col_n[8]}
N 5010 -6410 5010 -6350 {lab=col_n[8]}
N 5030 -6410 5030 -6350 {lab=col[8]}
N 5030 -6350 5040 -6340 {lab=col[8]}
N 5040 -6340 5040 -6090 {lab=col[8]}
N 5350 -6340 5350 -6090 {lab=col_n[9]}
N 5340 -6350 5350 -6340 {lab=col_n[9]}
N 5340 -6410 5340 -6350 {lab=col_n[9]}
N 5360 -6410 5360 -6350 {lab=col[9]}
N 5360 -6350 5370 -6340 {lab=col[9]}
N 5370 -6340 5370 -6090 {lab=col[9]}
N 5700 -6340 5700 -6090 {lab=col_n[10]}
N 5690 -6350 5700 -6340 {lab=col_n[10]}
N 5690 -6410 5690 -6350 {lab=col_n[10]}
N 5710 -6410 5710 -6350 {lab=col[10]}
N 5710 -6350 5720 -6340 {lab=col[10]}
N 5720 -6340 5720 -6090 {lab=col[10]}
N 6050 -6340 6050 -6090 {lab=col_n[11]}
N 6040 -6350 6050 -6340 {lab=col_n[11]}
N 6040 -6410 6040 -6350 {lab=col_n[11]}
N 6060 -6410 6060 -6350 {lab=col[11]}
N 6060 -6350 6070 -6340 {lab=col[11]}
N 6070 -6340 6070 -6090 {lab=col[11]}
N 6390 -6340 6390 -6090 {lab=col_n[12]}
N 6380 -6350 6390 -6340 {lab=col_n[12]}
N 6380 -6410 6380 -6350 {lab=col_n[12]}
N 6400 -6410 6400 -6350 {lab=col[12]}
N 6400 -6350 6410 -6340 {lab=col[12]}
N 6410 -6340 6410 -6090 {lab=col[12]}
N 6730 -6340 6730 -6090 {lab=VDD}
N 6720 -6350 6730 -6340 {lab=VDD}
N 6720 -6410 6720 -6350 {lab=VDD}
N 6740 -6410 6740 -6350 {lab=VSS}
N 6740 -6350 6750 -6340 {lab=VSS}
N 6750 -6340 6750 -6090 {lab=VSS}
N 6740 -6080 6750 -6090 {lab=VSS}
N 6720 -6080 6730 -6090 {lab=VDD}
N 6380 -6080 6390 -6090 {lab=col_n[12]}
N 6400 -6080 6410 -6090 {lab=col[12]}
N 6040 -6080 6050 -6090 {lab=col_n[11]}
N 6060 -6080 6070 -6090 {lab=col[11]}
N 5690 -6080 5700 -6090 {lab=col_n[10]}
N 5710 -6080 5720 -6090 {lab=col[10]}
N 5360 -6080 5370 -6090 {lab=col[9]}
N 5340 -6080 5350 -6090 {lab=col_n[9]}
N 5030 -6080 5040 -6090 {lab=col[8]}
N 5010 -6080 5020 -6090 {lab=col_n[8]}
N 4680 -6080 4690 -6090 {lab=col_n[7]}
N 4700 -6080 4710 -6090 {lab=col[7]}
N 4320 -6080 4330 -6090 {lab=col_n[6]}
N 4340 -6080 4350 -6090 {lab=col[6]}
N 3990 -6080 4000 -6090 {lab=col[5]}
N 3970 -6080 3980 -6090 {lab=col_n[5]}
N 3650 -6080 3660 -6090 {lab=col[4]}
N 3630 -6080 3640 -6090 {lab=col_n[4]}
N 3300 -6080 3310 -6090 {lab=col[3]}
N 3280 -6080 3290 -6090 {lab=col_n[3]}
N 2950 -6080 2960 -6090 {lab=col[2]}
N 2930 -6080 2940 -6090 {lab=col_n[2]}
N 2600 -6080 2610 -6090 {lab=col[1]}
N 2580 -6080 2590 -6090 {lab=col_n[1]}
N 2250 -6080 2260 -6090 {lab=col_n[0]}
N 2270 -6080 2280 -6090 {lab=col[0]}
N 1930 -5770 1940 -5780 {lab=VDD}
N 1930 -6080 1930 -6040 {lab=VDD}
N 1950 -5770 1960 -5780 {lab=VSS}
N 1960 -6020 1960 -5780 {lab=VSS}
N 1950 -6030 1960 -6020 {lab=VSS}
N 1950 -6080 1950 -6030 {lab=VSS}
N 1940 -6020 1940 -5780 {lab=VDD}
N 1930 -6030 1940 -6020 {lab=VDD}
N 1930 -6040 1930 -6030 {lab=VDD}
N 2250 -6080 2250 -6040 {lab=col_n[0]}
N 2280 -6020 2280 -5780 {lab=col[0]}
N 2270 -6030 2280 -6020 {lab=col[0]}
N 2270 -6080 2270 -6030 {lab=col[0]}
N 2260 -6020 2260 -5780 {lab=col_n[0]}
N 2250 -6030 2260 -6020 {lab=col_n[0]}
N 2250 -6040 2250 -6030 {lab=col_n[0]}
N 2580 -6080 2580 -6040 {lab=col_n[1]}
N 2610 -6020 2610 -5780 {lab=col[1]}
N 2600 -6030 2610 -6020 {lab=col[1]}
N 2600 -6080 2600 -6030 {lab=col[1]}
N 2590 -6020 2590 -5780 {lab=col_n[1]}
N 2580 -6030 2590 -6020 {lab=col_n[1]}
N 2580 -6040 2580 -6030 {lab=col_n[1]}
N 2930 -6080 2930 -6040 {lab=col_n[2]}
N 2960 -6020 2960 -5780 {lab=col[2]}
N 2950 -6030 2960 -6020 {lab=col[2]}
N 2950 -6080 2950 -6030 {lab=col[2]}
N 2940 -6020 2940 -5780 {lab=col_n[2]}
N 2930 -6030 2940 -6020 {lab=col_n[2]}
N 2930 -6040 2930 -6030 {lab=col_n[2]}
N 3280 -6080 3280 -6040 {lab=col_n[3]}
N 3310 -6020 3310 -5780 {lab=col[3]}
N 3300 -6030 3310 -6020 {lab=col[3]}
N 3300 -6080 3300 -6030 {lab=col[3]}
N 3290 -6020 3290 -5780 {lab=col_n[3]}
N 3280 -6030 3290 -6020 {lab=col_n[3]}
N 3280 -6040 3280 -6030 {lab=col_n[3]}
N 3630 -6080 3630 -6040 {lab=col_n[4]}
N 3660 -6020 3660 -5780 {lab=col[4]}
N 3650 -6030 3660 -6020 {lab=col[4]}
N 3650 -6080 3650 -6030 {lab=col[4]}
N 3640 -6020 3640 -5780 {lab=col_n[4]}
N 3630 -6030 3640 -6020 {lab=col_n[4]}
N 3630 -6040 3630 -6030 {lab=col_n[4]}
N 3970 -6080 3970 -6040 {lab=col_n[5]}
N 4000 -6020 4000 -5780 {lab=col[5]}
N 3990 -6030 4000 -6020 {lab=col[5]}
N 3990 -6080 3990 -6030 {lab=col[5]}
N 3980 -6020 3980 -5780 {lab=col_n[5]}
N 3970 -6030 3980 -6020 {lab=col_n[5]}
N 3970 -6040 3970 -6030 {lab=col_n[5]}
N 4320 -6080 4320 -6040 {lab=col_n[6]}
N 4350 -6020 4350 -5780 {lab=col[6]}
N 4340 -6030 4350 -6020 {lab=col[6]}
N 4340 -6080 4340 -6030 {lab=col[6]}
N 4330 -6020 4330 -5780 {lab=col_n[6]}
N 4320 -6030 4330 -6020 {lab=col_n[6]}
N 4320 -6040 4320 -6030 {lab=col_n[6]}
N 4680 -6080 4680 -6040 {lab=col_n[7]}
N 4710 -6020 4710 -5780 {lab=col[7]}
N 4700 -6030 4710 -6020 {lab=col[7]}
N 4700 -6080 4700 -6030 {lab=col[7]}
N 4690 -6020 4690 -5780 {lab=col_n[7]}
N 4680 -6030 4690 -6020 {lab=col_n[7]}
N 4680 -6040 4680 -6030 {lab=col_n[7]}
N 5010 -6080 5010 -6040 {lab=col_n[8]}
N 5040 -6020 5040 -5780 {lab=col[8]}
N 5030 -6030 5040 -6020 {lab=col[8]}
N 5030 -6080 5030 -6030 {lab=col[8]}
N 5020 -6020 5020 -5780 {lab=col_n[8]}
N 5010 -6030 5020 -6020 {lab=col_n[8]}
N 5010 -6040 5010 -6030 {lab=col_n[8]}
N 5340 -6080 5340 -6040 {lab=col_n[9]}
N 5370 -6020 5370 -5780 {lab=col[9]}
N 5360 -6030 5370 -6020 {lab=col[9]}
N 5360 -6080 5360 -6030 {lab=col[9]}
N 5350 -6020 5350 -5780 {lab=col_n[9]}
N 5340 -6030 5350 -6020 {lab=col_n[9]}
N 5340 -6040 5340 -6030 {lab=col_n[9]}
N 5690 -6080 5690 -6040 {lab=col_n[10]}
N 5720 -6020 5720 -5780 {lab=col[10]}
N 5710 -6030 5720 -6020 {lab=col[10]}
N 5710 -6080 5710 -6030 {lab=col[10]}
N 5700 -6020 5700 -5780 {lab=col_n[10]}
N 5690 -6030 5700 -6020 {lab=col_n[10]}
N 5690 -6040 5690 -6030 {lab=col_n[10]}
N 6040 -6080 6040 -6040 {lab=col_n[11]}
N 6070 -6020 6070 -5780 {lab=col[11]}
N 6060 -6030 6070 -6020 {lab=col[11]}
N 6060 -6080 6060 -6030 {lab=col[11]}
N 6050 -6020 6050 -5780 {lab=col_n[11]}
N 6040 -6030 6050 -6020 {lab=col_n[11]}
N 6040 -6040 6040 -6030 {lab=col_n[11]}
N 6380 -6080 6380 -6040 {lab=col_n[12]}
N 6410 -6020 6410 -5780 {lab=col[12]}
N 6400 -6030 6410 -6020 {lab=col[12]}
N 6400 -6080 6400 -6030 {lab=col[12]}
N 6390 -6020 6390 -5780 {lab=col_n[12]}
N 6380 -6030 6390 -6020 {lab=col_n[12]}
N 6380 -6040 6380 -6030 {lab=col_n[12]}
N 6720 -6080 6720 -6040 {lab=VDD}
N 6750 -6020 6750 -5780 {lab=VSS}
N 6740 -6030 6750 -6020 {lab=VSS}
N 6740 -6080 6740 -6030 {lab=VSS}
N 6730 -6020 6730 -5780 {lab=VDD}
N 6720 -6030 6730 -6020 {lab=VDD}
N 6720 -6040 6720 -6030 {lab=VDD}
N 6740 -5770 6750 -5780 {lab=VSS}
N 6720 -5770 6730 -5780 {lab=VDD}
N 6400 -5770 6410 -5780 {lab=col[12]}
N 6380 -5770 6390 -5780 {lab=col_n[12]}
N 6060 -5770 6070 -5780 {lab=col[11]}
N 6040 -5770 6050 -5780 {lab=col_n[11]}
N 5710 -5770 5720 -5780 {lab=col[10]}
N 5690 -5770 5700 -5780 {lab=col_n[10]}
N 5360 -5770 5370 -5780 {lab=col[9]}
N 5340 -5770 5350 -5780 {lab=col_n[9]}
N 5030 -5770 5040 -5780 {lab=col[8]}
N 5010 -5770 5020 -5780 {lab=col_n[8]}
N 4700 -5770 4710 -5780 {lab=col[7]}
N 4680 -5770 4690 -5780 {lab=col_n[7]}
N 4340 -5770 4350 -5780 {lab=col[6]}
N 4320 -5770 4330 -5780 {lab=col_n[6]}
N 3990 -5770 4000 -5780 {lab=col[5]}
N 3970 -5770 3980 -5780 {lab=col_n[5]}
N 3650 -5770 3660 -5780 {lab=col[4]}
N 3630 -5770 3640 -5780 {lab=col_n[4]}
N 3300 -5770 3310 -5780 {lab=col[3]}
N 3280 -5770 3290 -5780 {lab=col_n[3]}
N 2950 -5770 2960 -5780 {lab=col[2]}
N 2930 -5770 2940 -5780 {lab=col_n[2]}
N 2600 -5770 2610 -5780 {lab=col[1]}
N 2580 -5770 2590 -5780 {lab=col_n[1]}
N 2270 -5770 2280 -5780 {lab=col[0]}
N 2250 -5770 2260 -5780 {lab=col_n[0]}
N 2030 -3260 2130 -3260 {lab=#net21}
N 2030 -3240 2130 -3240 {lab=#net22}
N 1820 -3330 2040 -3330 {lab=rowoff_n[0]}
N 2040 -3330 2050 -3320 {lab=rowoff_n[0]}
N 2050 -3320 2130 -3320 {lab=rowoff_n[0]}
N 1820 -3310 2040 -3310 {lab=row_n[0]}
N 2040 -3310 2050 -3300 {lab=row_n[0]}
N 2050 -3300 2130 -3300 {lab=row_n[0]}
N 1820 -3290 2040 -3290 {lab=rowon_n[0]}
N 2040 -3290 2050 -3280 {lab=rowon_n[0]}
N 2050 -3280 2130 -3280 {lab=rowon_n[0]}
N 1930 -3160 1940 -3170 {lab=VDD}
N 1940 -3410 1940 -3170 {lab=VDD}
N 1950 -3160 1960 -3170 {lab=VSS}
N 1960 -3410 1960 -3170 {lab=VSS}
N 1810 -3320 1820 -3330 {lab=rowoff_n[0]}
N 1810 -3300 1820 -3310 {lab=row_n[0]}
N 1810 -3280 1820 -3290 {lab=rowon_n[0]}
N 2250 -3420 2260 -3410 {lab=col_n[0]}
N 2250 -3460 2250 -3420 {lab=col_n[0]}
N 2270 -3460 2270 -3420 {lab=col[0]}
N 2270 -3420 2280 -3410 {lab=col[0]}
N 2260 -3410 2260 -3170 {lab=col_n[0]}
N 2280 -3410 2280 -3170 {lab=col[0]}
N 2580 -3420 2590 -3410 {lab=col_n[1]}
N 2580 -3460 2580 -3420 {lab=col_n[1]}
N 2600 -3460 2600 -3420 {lab=col[1]}
N 2600 -3420 2610 -3410 {lab=col[1]}
N 2590 -3410 2590 -3170 {lab=col_n[1]}
N 2610 -3410 2610 -3170 {lab=col[1]}
N 2930 -3420 2940 -3410 {lab=col_n[2]}
N 2930 -3460 2930 -3420 {lab=col_n[2]}
N 2950 -3460 2950 -3420 {lab=col[2]}
N 2950 -3420 2960 -3410 {lab=col[2]}
N 2940 -3410 2940 -3170 {lab=col_n[2]}
N 2960 -3410 2960 -3170 {lab=col[2]}
N 3280 -3420 3290 -3410 {lab=col_n[3]}
N 3280 -3460 3280 -3420 {lab=col_n[3]}
N 3300 -3460 3300 -3420 {lab=col[3]}
N 3300 -3420 3310 -3410 {lab=col[3]}
N 3290 -3410 3290 -3170 {lab=col_n[3]}
N 3310 -3410 3310 -3170 {lab=col[3]}
N 3630 -3420 3640 -3410 {lab=col_n[4]}
N 3630 -3460 3630 -3420 {lab=col_n[4]}
N 3650 -3460 3650 -3420 {lab=col[4]}
N 3650 -3420 3660 -3410 {lab=col[4]}
N 3640 -3410 3640 -3170 {lab=col_n[4]}
N 3660 -3410 3660 -3170 {lab=col[4]}
N 3970 -3420 3980 -3410 {lab=col_n[5]}
N 3970 -3460 3970 -3420 {lab=col_n[5]}
N 3990 -3460 3990 -3420 {lab=col[5]}
N 3990 -3420 4000 -3410 {lab=col[5]}
N 3980 -3410 3980 -3170 {lab=col_n[5]}
N 4000 -3410 4000 -3170 {lab=col[5]}
N 4320 -3420 4330 -3410 {lab=col_n[6]}
N 4320 -3460 4320 -3420 {lab=col_n[6]}
N 4340 -3460 4340 -3420 {lab=col[6]}
N 4340 -3420 4350 -3410 {lab=col[6]}
N 4330 -3410 4330 -3170 {lab=col_n[6]}
N 4350 -3410 4350 -3170 {lab=col[6]}
N 4680 -3420 4690 -3410 {lab=col_n[7]}
N 4680 -3460 4680 -3420 {lab=col_n[7]}
N 4700 -3460 4700 -3420 {lab=col[7]}
N 4700 -3420 4710 -3410 {lab=col[7]}
N 4690 -3410 4690 -3170 {lab=col_n[7]}
N 4710 -3410 4710 -3170 {lab=col[7]}
N 5010 -3420 5020 -3410 {lab=col_n[8]}
N 5010 -3460 5010 -3420 {lab=col_n[8]}
N 5030 -3460 5030 -3420 {lab=col[8]}
N 5030 -3420 5040 -3410 {lab=col[8]}
N 5020 -3410 5020 -3170 {lab=col_n[8]}
N 5040 -3410 5040 -3170 {lab=col[8]}
N 5340 -3420 5350 -3410 {lab=col_n[9]}
N 5340 -3460 5340 -3420 {lab=col_n[9]}
N 5360 -3460 5360 -3420 {lab=col[9]}
N 5360 -3420 5370 -3410 {lab=col[9]}
N 5350 -3410 5350 -3170 {lab=col_n[9]}
N 5370 -3410 5370 -3170 {lab=col[9]}
N 5690 -3420 5700 -3410 {lab=col_n[10]}
N 5690 -3460 5690 -3420 {lab=col_n[10]}
N 5710 -3460 5710 -3420 {lab=col[10]}
N 5710 -3420 5720 -3410 {lab=col[10]}
N 5700 -3410 5700 -3170 {lab=col_n[10]}
N 5720 -3410 5720 -3170 {lab=col[10]}
N 6040 -3420 6050 -3410 {lab=col_n[11]}
N 6040 -3460 6040 -3420 {lab=col_n[11]}
N 6060 -3460 6060 -3420 {lab=col[11]}
N 6060 -3420 6070 -3410 {lab=col[11]}
N 6050 -3410 6050 -3170 {lab=col_n[11]}
N 6070 -3410 6070 -3170 {lab=col[11]}
N 6380 -3420 6390 -3410 {lab=col_n[12]}
N 6380 -3460 6380 -3420 {lab=col_n[12]}
N 6400 -3460 6400 -3420 {lab=col[12]}
N 6400 -3420 6410 -3410 {lab=col[12]}
N 6390 -3410 6390 -3170 {lab=col_n[12]}
N 6410 -3410 6410 -3170 {lab=col[12]}
N 6720 -3420 6730 -3410 {lab=VDD}
N 6720 -3460 6720 -3420 {lab=VDD}
N 6740 -3460 6740 -3420 {lab=VSS}
N 6740 -3420 6750 -3410 {lab=VSS}
N 6730 -3410 6730 -3170 {lab=VDD}
N 6750 -3410 6750 -3170 {lab=VSS}
N 2250 -3160 2260 -3170 {lab=col_n[0]}
N 2270 -3160 2280 -3170 {lab=col[0]}
N 2130 -3320 2140 -3330 {lab=rowoff_n[0]}
N 2140 -3330 2340 -3330 {lab=rowoff_n[0]}
N 2340 -3330 2350 -3320 {lab=rowoff_n[0]}
N 2350 -3320 2460 -3320 {lab=rowoff_n[0]}
N 2130 -3300 2140 -3310 {lab=row_n[0]}
N 2140 -3310 2340 -3310 {lab=row_n[0]}
N 2340 -3310 2350 -3300 {lab=row_n[0]}
N 2350 -3300 2460 -3300 {lab=row_n[0]}
N 2130 -3280 2140 -3290 {lab=rowon_n[0]}
N 2140 -3290 2340 -3290 {lab=rowon_n[0]}
N 2340 -3290 2350 -3280 {lab=rowon_n[0]}
N 2350 -3280 2460 -3280 {lab=rowon_n[0]}
N 2130 -3260 2140 -3270 {lab=#net21}
N 2140 -3270 2340 -3270 {lab=#net21}
N 2340 -3270 2350 -3260 {lab=#net21}
N 2350 -3260 2460 -3260 {lab=#net21}
N 2130 -3240 2140 -3250 {lab=#net22}
N 2140 -3250 2340 -3250 {lab=#net22}
N 2340 -3250 2350 -3240 {lab=#net22}
N 2350 -3240 2460 -3240 {lab=#net22}
N 2580 -3160 2590 -3170 {lab=col_n[1]}
N 2600 -3160 2610 -3170 {lab=col[1]}
N 2490 -3330 2690 -3330 {lab=rowoff_n[0]}
N 2690 -3330 2700 -3320 {lab=rowoff_n[0]}
N 2700 -3320 2810 -3320 {lab=rowoff_n[0]}
N 2490 -3310 2690 -3310 {lab=row_n[0]}
N 2690 -3310 2700 -3300 {lab=row_n[0]}
N 2700 -3300 2810 -3300 {lab=row_n[0]}
N 2490 -3290 2690 -3290 {lab=rowon_n[0]}
N 2690 -3290 2700 -3280 {lab=rowon_n[0]}
N 2700 -3280 2810 -3280 {lab=rowon_n[0]}
N 2490 -3270 2690 -3270 {lab=#net21}
N 2690 -3270 2700 -3260 {lab=#net21}
N 2700 -3260 2810 -3260 {lab=#net21}
N 2490 -3250 2690 -3250 {lab=#net22}
N 2690 -3250 2700 -3240 {lab=#net22}
N 2700 -3240 2810 -3240 {lab=#net22}
N 2460 -3320 2470 -3330 {lab=rowoff_n[0]}
N 2470 -3330 2490 -3330 {lab=rowoff_n[0]}
N 2460 -3300 2470 -3310 {lab=row_n[0]}
N 2470 -3310 2490 -3310 {lab=row_n[0]}
N 2460 -3280 2470 -3290 {lab=rowon_n[0]}
N 2470 -3290 2490 -3290 {lab=rowon_n[0]}
N 2460 -3260 2470 -3270 {lab=#net21}
N 2470 -3270 2490 -3270 {lab=#net21}
N 2460 -3240 2470 -3250 {lab=#net22}
N 2470 -3250 2490 -3250 {lab=#net22}
N 2930 -3160 2940 -3170 {lab=col_n[2]}
N 2950 -3160 2960 -3170 {lab=col[2]}
N 2840 -3330 3040 -3330 {lab=rowoff_n[0]}
N 3040 -3330 3050 -3320 {lab=rowoff_n[0]}
N 3050 -3320 3160 -3320 {lab=rowoff_n[0]}
N 2840 -3310 3040 -3310 {lab=row_n[0]}
N 3040 -3310 3050 -3300 {lab=row_n[0]}
N 3050 -3300 3160 -3300 {lab=row_n[0]}
N 2840 -3290 3040 -3290 {lab=rowon_n[0]}
N 3040 -3290 3050 -3280 {lab=rowon_n[0]}
N 3050 -3280 3160 -3280 {lab=rowon_n[0]}
N 2840 -3270 3040 -3270 {lab=#net21}
N 3040 -3270 3050 -3260 {lab=#net21}
N 3050 -3260 3160 -3260 {lab=#net21}
N 2840 -3250 3040 -3250 {lab=#net22}
N 3040 -3250 3050 -3240 {lab=#net22}
N 3050 -3240 3160 -3240 {lab=#net22}
N 2810 -3320 2820 -3330 {lab=rowoff_n[0]}
N 2820 -3330 2840 -3330 {lab=rowoff_n[0]}
N 2810 -3300 2820 -3310 {lab=row_n[0]}
N 2820 -3310 2840 -3310 {lab=row_n[0]}
N 2810 -3280 2820 -3290 {lab=rowon_n[0]}
N 2820 -3290 2840 -3290 {lab=rowon_n[0]}
N 2810 -3260 2820 -3270 {lab=#net21}
N 2820 -3270 2840 -3270 {lab=#net21}
N 2810 -3240 2820 -3250 {lab=#net22}
N 2820 -3250 2840 -3250 {lab=#net22}
N 3280 -3160 3290 -3170 {lab=col_n[3]}
N 3300 -3160 3310 -3170 {lab=col[3]}
N 3630 -3160 3640 -3170 {lab=col_n[4]}
N 3650 -3160 3660 -3170 {lab=col[4]}
N 3160 -3320 3170 -3330 {lab=rowoff_n[0]}
N 3170 -3330 3190 -3330 {lab=rowoff_n[0]}
N 3160 -3300 3170 -3310 {lab=row_n[0]}
N 3170 -3310 3190 -3310 {lab=row_n[0]}
N 3160 -3280 3170 -3290 {lab=rowon_n[0]}
N 3170 -3290 3190 -3290 {lab=rowon_n[0]}
N 3160 -3260 3170 -3270 {lab=#net21}
N 3170 -3270 3190 -3270 {lab=#net21}
N 3160 -3240 3170 -3250 {lab=#net22}
N 3170 -3250 3190 -3250 {lab=#net22}
N 3190 -3330 3370 -3330 {lab=rowoff_n[0]}
N 3370 -3330 3380 -3320 {lab=rowoff_n[0]}
N 3380 -3320 3510 -3320 {lab=rowoff_n[0]}
N 3190 -3310 3370 -3310 {lab=row_n[0]}
N 3370 -3310 3380 -3300 {lab=row_n[0]}
N 3380 -3300 3510 -3300 {lab=row_n[0]}
N 3190 -3290 3370 -3290 {lab=rowon_n[0]}
N 3370 -3290 3380 -3280 {lab=rowon_n[0]}
N 3380 -3280 3510 -3280 {lab=rowon_n[0]}
N 3190 -3270 3370 -3270 {lab=#net21}
N 3190 -3250 3370 -3250 {lab=#net22}
N 3370 -3250 3380 -3240 {lab=#net22}
N 3380 -3240 3510 -3240 {lab=#net22}
N 3380 -3260 3510 -3260 {lab=#net21}
N 3370 -3270 3380 -3260 {lab=#net21}
N 3970 -3160 3980 -3170 {lab=col_n[5]}
N 3990 -3160 4000 -3170 {lab=col[5]}
N 3510 -3320 3520 -3330 {lab=rowoff_n[0]}
N 3520 -3330 3720 -3330 {lab=rowoff_n[0]}
N 3510 -3300 3520 -3310 {lab=row_n[0]}
N 3520 -3310 3720 -3310 {lab=row_n[0]}
N 3720 -3310 3730 -3300 {lab=row_n[0]}
N 3730 -3300 3850 -3300 {lab=row_n[0]}
N 3720 -3330 3730 -3320 {lab=rowoff_n[0]}
N 3730 -3320 3850 -3320 {lab=rowoff_n[0]}
N 3510 -3280 3520 -3290 {lab=rowon_n[0]}
N 3520 -3290 3720 -3290 {lab=rowon_n[0]}
N 3720 -3290 3730 -3280 {lab=rowon_n[0]}
N 3730 -3280 3850 -3280 {lab=rowon_n[0]}
N 3510 -3260 3520 -3270 {lab=#net21}
N 3520 -3270 3720 -3270 {lab=#net21}
N 3720 -3270 3730 -3260 {lab=#net21}
N 3730 -3260 3850 -3260 {lab=#net21}
N 3510 -3240 3520 -3250 {lab=#net22}
N 3520 -3250 3720 -3250 {lab=#net22}
N 3720 -3250 3730 -3240 {lab=#net22}
N 3730 -3240 3850 -3240 {lab=#net22}
N 3850 -3320 3860 -3330 {lab=rowoff_n[0]}
N 3860 -3330 4060 -3330 {lab=rowoff_n[0]}
N 3850 -3300 3860 -3310 {lab=row_n[0]}
N 3860 -3310 4060 -3310 {lab=row_n[0]}
N 4060 -3310 4070 -3300 {lab=row_n[0]}
N 4070 -3300 4200 -3300 {lab=row_n[0]}
N 4070 -3320 4200 -3320 {lab=rowoff_n[0]}
N 4060 -3330 4070 -3320 {lab=rowoff_n[0]}
N 3850 -3280 3860 -3290 {lab=rowon_n[0]}
N 3860 -3290 4060 -3290 {lab=rowon_n[0]}
N 4060 -3290 4070 -3280 {lab=rowon_n[0]}
N 4070 -3280 4200 -3280 {lab=rowon_n[0]}
N 3850 -3260 3860 -3270 {lab=#net21}
N 3860 -3270 4060 -3270 {lab=#net21}
N 4060 -3270 4070 -3260 {lab=#net21}
N 4070 -3260 4200 -3260 {lab=#net21}
N 3850 -3240 3860 -3250 {lab=#net22}
N 3860 -3250 4060 -3250 {lab=#net22}
N 4060 -3250 4070 -3240 {lab=#net22}
N 4070 -3240 4200 -3240 {lab=#net22}
N 4320 -3160 4330 -3170 {lab=col_n[6]}
N 4340 -3160 4350 -3170 {lab=col[6]}
N 4200 -3320 4210 -3330 {lab=rowoff_n[0]}
N 4210 -3330 4410 -3330 {lab=rowoff_n[0]}
N 4410 -3330 4420 -3320 {lab=rowoff_n[0]}
N 4420 -3320 4560 -3320 {lab=rowoff_n[0]}
N 4200 -3300 4210 -3310 {lab=row_n[0]}
N 4210 -3310 4410 -3310 {lab=row_n[0]}
N 4420 -3300 4560 -3300 {lab=row_n[0]}
N 4410 -3310 4420 -3300 {lab=row_n[0]}
N 4420 -3280 4560 -3280 {lab=rowon_n[0]}
N 4410 -3290 4420 -3280 {lab=rowon_n[0]}
N 4210 -3290 4410 -3290 {lab=rowon_n[0]}
N 4200 -3280 4210 -3290 {lab=rowon_n[0]}
N 4200 -3260 4210 -3270 {lab=#net21}
N 4210 -3270 4410 -3270 {lab=#net21}
N 4410 -3270 4420 -3260 {lab=#net21}
N 4420 -3260 4560 -3260 {lab=#net21}
N 4200 -3240 4210 -3250 {lab=#net22}
N 4210 -3250 4410 -3250 {lab=#net22}
N 4410 -3250 4420 -3240 {lab=#net22}
N 4420 -3240 4560 -3240 {lab=#net22}
N 4680 -3160 4690 -3170 {lab=col_n[7]}
N 4700 -3160 4710 -3170 {lab=col[7]}
N 4560 -3320 4570 -3330 {lab=rowoff_n[0]}
N 4570 -3330 4770 -3330 {lab=rowoff_n[0]}
N 4770 -3330 4780 -3320 {lab=rowoff_n[0]}
N 4780 -3320 4890 -3320 {lab=rowoff_n[0]}
N 4560 -3300 4570 -3310 {lab=row_n[0]}
N 4570 -3310 4770 -3310 {lab=row_n[0]}
N 4770 -3310 4780 -3300 {lab=row_n[0]}
N 4780 -3300 4890 -3300 {lab=row_n[0]}
N 4560 -3280 4570 -3290 {lab=rowon_n[0]}
N 4570 -3290 4770 -3290 {lab=rowon_n[0]}
N 4770 -3290 4780 -3280 {lab=rowon_n[0]}
N 4780 -3280 4890 -3280 {lab=rowon_n[0]}
N 4560 -3260 4570 -3270 {lab=#net21}
N 4570 -3270 4770 -3270 {lab=#net21}
N 4770 -3270 4780 -3260 {lab=#net21}
N 4780 -3260 4890 -3260 {lab=#net21}
N 4560 -3240 4570 -3250 {lab=#net22}
N 4570 -3250 4770 -3250 {lab=#net22}
N 4770 -3250 4780 -3240 {lab=#net22}
N 4780 -3240 4890 -3240 {lab=#net22}
N 5010 -3160 5020 -3170 {lab=col_n[8]}
N 5030 -3160 5040 -3170 {lab=col[8]}
N 5340 -3160 5350 -3170 {lab=col_n[9]}
N 5360 -3160 5370 -3170 {lab=col[9]}
N 4890 -3320 4900 -3330 {lab=rowoff_n[0]}
N 4900 -3330 5100 -3330 {lab=rowoff_n[0]}
N 5100 -3330 5110 -3320 {lab=rowoff_n[0]}
N 5110 -3320 5220 -3320 {lab=rowoff_n[0]}
N 5110 -3300 5220 -3300 {lab=row_n[0]}
N 5100 -3310 5110 -3300 {lab=row_n[0]}
N 4900 -3310 5100 -3310 {lab=row_n[0]}
N 4890 -3300 4900 -3310 {lab=row_n[0]}
N 4890 -3280 4900 -3290 {lab=rowon_n[0]}
N 4900 -3290 5100 -3290 {lab=rowon_n[0]}
N 5100 -3290 5110 -3280 {lab=rowon_n[0]}
N 5110 -3280 5220 -3280 {lab=rowon_n[0]}
N 5110 -3260 5220 -3260 {lab=#net21}
N 5100 -3270 5110 -3260 {lab=#net21}
N 4900 -3270 5100 -3270 {lab=#net21}
N 4890 -3260 4900 -3270 {lab=#net21}
N 4890 -3240 4900 -3250 {lab=#net22}
N 4900 -3250 5100 -3250 {lab=#net22}
N 5100 -3250 5110 -3240 {lab=#net22}
N 5110 -3240 5220 -3240 {lab=#net22}
N 5220 -3320 5230 -3330 {lab=rowoff_n[0]}
N 5230 -3330 5430 -3330 {lab=rowoff_n[0]}
N 5430 -3330 5440 -3320 {lab=rowoff_n[0]}
N 5440 -3320 5570 -3320 {lab=rowoff_n[0]}
N 5440 -3300 5570 -3300 {lab=row_n[0]}
N 5430 -3310 5440 -3300 {lab=row_n[0]}
N 5230 -3310 5430 -3310 {lab=row_n[0]}
N 5220 -3300 5230 -3310 {lab=row_n[0]}
N 5220 -3280 5230 -3290 {lab=rowon_n[0]}
N 5230 -3290 5430 -3290 {lab=rowon_n[0]}
N 5430 -3290 5440 -3280 {lab=rowon_n[0]}
N 5440 -3280 5570 -3280 {lab=rowon_n[0]}
N 5440 -3260 5570 -3260 {lab=#net21}
N 5430 -3270 5440 -3260 {lab=#net21}
N 5230 -3270 5430 -3270 {lab=#net21}
N 5220 -3260 5230 -3270 {lab=#net21}
N 5220 -3240 5230 -3250 {lab=#net22}
N 5230 -3250 5430 -3250 {lab=#net22}
N 5430 -3250 5440 -3240 {lab=#net22}
N 5440 -3240 5570 -3240 {lab=#net22}
N 5570 -3320 5580 -3330 {lab=rowoff_n[0]}
N 5580 -3330 5780 -3330 {lab=rowoff_n[0]}
N 5780 -3330 5790 -3320 {lab=rowoff_n[0]}
N 5790 -3320 5920 -3320 {lab=rowoff_n[0]}
N 5570 -3300 5580 -3310 {lab=row_n[0]}
N 5580 -3310 5780 -3310 {lab=row_n[0]}
N 5780 -3310 5790 -3300 {lab=row_n[0]}
N 5790 -3300 5920 -3300 {lab=row_n[0]}
N 5570 -3280 5580 -3290 {lab=rowon_n[0]}
N 5580 -3290 5780 -3290 {lab=rowon_n[0]}
N 5780 -3290 5790 -3280 {lab=rowon_n[0]}
N 5790 -3280 5920 -3280 {lab=rowon_n[0]}
N 5570 -3260 5580 -3270 {lab=#net21}
N 5580 -3270 5780 -3270 {lab=#net21}
N 5780 -3270 5790 -3260 {lab=#net21}
N 5790 -3260 5920 -3260 {lab=#net21}
N 5570 -3240 5580 -3250 {lab=#net22}
N 5580 -3250 5780 -3250 {lab=#net22}
N 5780 -3250 5790 -3240 {lab=#net22}
N 5790 -3240 5920 -3240 {lab=#net22}
N 5690 -3160 5700 -3170 {lab=col_n[10]}
N 5710 -3160 5720 -3170 {lab=col[10]}
N 6040 -3160 6050 -3170 {lab=col_n[11]}
N 6060 -3160 6070 -3170 {lab=col[11]}
N 5920 -3320 5930 -3330 {lab=rowoff_n[0]}
N 5930 -3330 6130 -3330 {lab=rowoff_n[0]}
N 6130 -3330 6140 -3320 {lab=rowoff_n[0]}
N 6140 -3320 6260 -3320 {lab=rowoff_n[0]}
N 5920 -3300 5930 -3310 {lab=row_n[0]}
N 5930 -3310 6130 -3310 {lab=row_n[0]}
N 6130 -3310 6140 -3300 {lab=row_n[0]}
N 6140 -3300 6260 -3300 {lab=row_n[0]}
N 5920 -3280 5930 -3290 {lab=rowon_n[0]}
N 5930 -3290 6130 -3290 {lab=rowon_n[0]}
N 6130 -3290 6140 -3280 {lab=rowon_n[0]}
N 6140 -3280 6260 -3280 {lab=rowon_n[0]}
N 5920 -3260 5930 -3270 {lab=#net21}
N 5930 -3270 6130 -3270 {lab=#net21}
N 6130 -3270 6140 -3260 {lab=#net21}
N 6140 -3260 6260 -3260 {lab=#net21}
N 5920 -3240 5930 -3250 {lab=#net22}
N 5930 -3250 6130 -3250 {lab=#net22}
N 6130 -3250 6140 -3240 {lab=#net22}
N 6140 -3240 6260 -3240 {lab=#net22}
N 6260 -3320 6270 -3330 {lab=rowoff_n[0]}
N 6270 -3330 6470 -3330 {lab=rowoff_n[0]}
N 6470 -3330 6480 -3320 {lab=rowoff_n[0]}
N 6480 -3320 6600 -3320 {lab=rowoff_n[0]}
N 6260 -3300 6270 -3310 {lab=row_n[0]}
N 6270 -3310 6470 -3310 {lab=row_n[0]}
N 6470 -3310 6480 -3300 {lab=row_n[0]}
N 6480 -3300 6600 -3300 {lab=row_n[0]}
N 6260 -3280 6270 -3290 {lab=rowon_n[0]}
N 6270 -3290 6470 -3290 {lab=rowon_n[0]}
N 6470 -3290 6480 -3280 {lab=rowon_n[0]}
N 6480 -3280 6600 -3280 {lab=rowon_n[0]}
N 6260 -3260 6270 -3270 {lab=#net21}
N 6270 -3270 6470 -3270 {lab=#net21}
N 6470 -3270 6480 -3260 {lab=#net21}
N 6480 -3260 6600 -3260 {lab=#net21}
N 6260 -3240 6270 -3250 {lab=#net22}
N 6270 -3250 6470 -3250 {lab=#net22}
N 6470 -3250 6480 -3240 {lab=#net22}
N 6480 -3240 6600 -3240 {lab=#net22}
N 6380 -3160 6390 -3170 {lab=col_n[12]}
N 6400 -3160 6410 -3170 {lab=col[12]}
N 6720 -3160 6730 -3170 {lab=VDD}
N 6740 -3160 6750 -3170 {lab=VSS}
N 6600 -3320 6610 -3330 {lab=rowoff_n[0]}
N 6610 -3330 6810 -3330 {lab=rowoff_n[0]}
N 6810 -3330 6820 -3320 {lab=rowoff_n[0]}
N 6600 -3300 6610 -3310 {lab=row_n[0]}
N 6610 -3310 6810 -3310 {lab=row_n[0]}
N 6810 -3310 6820 -3300 {lab=row_n[0]}
N 6600 -3280 6610 -3290 {lab=rowon_n[0]}
N 6610 -3290 6810 -3290 {lab=rowon_n[0]}
N 6810 -3290 6820 -3280 {lab=rowon_n[0]}
N 6600 -3260 6610 -3270 {lab=#net21}
N 6610 -3270 6810 -3270 {lab=#net21}
N 6810 -3270 6820 -3260 {lab=#net21}
N 6600 -3240 6610 -3250 {lab=#net22}
N 6610 -3250 6810 -3250 {lab=#net22}
N 6810 -3250 6820 -3240 {lab=#net22}
N 1930 -2840 1940 -2850 {lab=VDD}
N 1940 -3110 1940 -2850 {lab=VDD}
N 1930 -3120 1940 -3110 {lab=VDD}
N 1930 -3160 1930 -3120 {lab=VDD}
N 1950 -2840 1960 -2850 {lab=VSS}
N 1960 -3110 1960 -2850 {lab=VSS}
N 1950 -3120 1960 -3110 {lab=VSS}
N 1950 -3160 1950 -3120 {lab=VSS}
N 2260 -3110 2260 -2850 {lab=col_n[0]}
N 2250 -3120 2260 -3110 {lab=col_n[0]}
N 2250 -3160 2250 -3120 {lab=col_n[0]}
N 2280 -3110 2280 -2850 {lab=col[0]}
N 2270 -3120 2280 -3110 {lab=col[0]}
N 2270 -3160 2270 -3120 {lab=col[0]}
N 2590 -3110 2590 -2850 {lab=col_n[1]}
N 2580 -3120 2590 -3110 {lab=col_n[1]}
N 2580 -3160 2580 -3120 {lab=col_n[1]}
N 2610 -3110 2610 -2850 {lab=col[1]}
N 2600 -3120 2610 -3110 {lab=col[1]}
N 2600 -3160 2600 -3120 {lab=col[1]}
N 2940 -3110 2940 -2850 {lab=col_n[2]}
N 2930 -3120 2940 -3110 {lab=col_n[2]}
N 2930 -3160 2930 -3120 {lab=col_n[2]}
N 2960 -3110 2960 -2850 {lab=col[2]}
N 2950 -3120 2960 -3110 {lab=col[2]}
N 2950 -3160 2950 -3120 {lab=col[2]}
N 3290 -3110 3290 -2850 {lab=col_n[3]}
N 3280 -3120 3290 -3110 {lab=col_n[3]}
N 3280 -3160 3280 -3120 {lab=col_n[3]}
N 3310 -3110 3310 -2850 {lab=col[3]}
N 3300 -3120 3310 -3110 {lab=col[3]}
N 3300 -3160 3300 -3120 {lab=col[3]}
N 3640 -3110 3640 -2850 {lab=col_n[4]}
N 3630 -3120 3640 -3110 {lab=col_n[4]}
N 3630 -3160 3630 -3120 {lab=col_n[4]}
N 3660 -3110 3660 -2850 {lab=col[4]}
N 3650 -3120 3660 -3110 {lab=col[4]}
N 3650 -3160 3650 -3120 {lab=col[4]}
N 3980 -3110 3980 -2850 {lab=col_n[5]}
N 3970 -3120 3980 -3110 {lab=col_n[5]}
N 3970 -3160 3970 -3120 {lab=col_n[5]}
N 4000 -3110 4000 -2850 {lab=col[5]}
N 3990 -3120 4000 -3110 {lab=col[5]}
N 3990 -3160 3990 -3120 {lab=col[5]}
N 4330 -3110 4330 -2850 {lab=col_n[6]}
N 4320 -3120 4330 -3110 {lab=col_n[6]}
N 4320 -3160 4320 -3120 {lab=col_n[6]}
N 4350 -3110 4350 -2850 {lab=col[6]}
N 4340 -3120 4350 -3110 {lab=col[6]}
N 4340 -3160 4340 -3120 {lab=col[6]}
N 4690 -3110 4690 -2850 {lab=col_n[7]}
N 4680 -3120 4690 -3110 {lab=col_n[7]}
N 4680 -3160 4680 -3120 {lab=col_n[7]}
N 4710 -3110 4710 -2850 {lab=col[7]}
N 4700 -3120 4710 -3110 {lab=col[7]}
N 4700 -3160 4700 -3120 {lab=col[7]}
N 5020 -3110 5020 -2850 {lab=col_n[8]}
N 5010 -3120 5020 -3110 {lab=col_n[8]}
N 5010 -3160 5010 -3120 {lab=col_n[8]}
N 5040 -3110 5040 -2850 {lab=col[8]}
N 5030 -3120 5040 -3110 {lab=col[8]}
N 5030 -3160 5030 -3120 {lab=col[8]}
N 5350 -3110 5350 -2850 {lab=col_n[9]}
N 5340 -3120 5350 -3110 {lab=col_n[9]}
N 5340 -3160 5340 -3120 {lab=col_n[9]}
N 5370 -3110 5370 -2850 {lab=col[9]}
N 5360 -3120 5370 -3110 {lab=col[9]}
N 5360 -3160 5360 -3120 {lab=col[9]}
N 5700 -3110 5700 -2850 {lab=col_n[10]}
N 5690 -3120 5700 -3110 {lab=col_n[10]}
N 5690 -3160 5690 -3120 {lab=col_n[10]}
N 5720 -3110 5720 -2850 {lab=col[10]}
N 5710 -3120 5720 -3110 {lab=col[10]}
N 5710 -3160 5710 -3120 {lab=col[10]}
N 6050 -3110 6050 -2850 {lab=col_n[11]}
N 6040 -3120 6050 -3110 {lab=col_n[11]}
N 6040 -3160 6040 -3120 {lab=col_n[11]}
N 6070 -3110 6070 -2850 {lab=col[11]}
N 6060 -3120 6070 -3110 {lab=col[11]}
N 6060 -3160 6060 -3120 {lab=col[11]}
N 6390 -3110 6390 -2850 {lab=col_n[12]}
N 6380 -3120 6390 -3110 {lab=col_n[12]}
N 6380 -3160 6380 -3120 {lab=col_n[12]}
N 6410 -3110 6410 -2850 {lab=col[12]}
N 6400 -3120 6410 -3110 {lab=col[12]}
N 6400 -3160 6400 -3120 {lab=col[12]}
N 6730 -3110 6730 -2850 {lab=VDD}
N 6720 -3120 6730 -3110 {lab=VDD}
N 6720 -3160 6720 -3120 {lab=VDD}
N 6750 -3110 6750 -2850 {lab=VSS}
N 6740 -3120 6750 -3110 {lab=VSS}
N 6740 -3160 6740 -3120 {lab=VSS}
N 6720 -2840 6730 -2850 {lab=VDD}
N 6740 -2840 6750 -2850 {lab=VSS}
N 2030 -2940 2130 -2940 {lab=#net23}
N 2030 -2920 2130 -2920 {lab=#net24}
N 2250 -2840 2260 -2850 {lab=col_n[0]}
N 2270 -2840 2280 -2850 {lab=col[0]}
N 1810 -3000 1820 -3010 {lab=VDD}
N 1820 -3010 2020 -3010 {lab=VDD}
N 2020 -3010 2030 -3000 {lab=VDD}
N 2030 -3000 2130 -3000 {lab=VDD}
N 1810 -2980 1820 -2990 {lab=VDD}
N 1820 -2990 2020 -2990 {lab=VDD}
N 2020 -2990 2030 -2980 {lab=VDD}
N 2030 -2980 2130 -2980 {lab=VDD}
N 1810 -2960 1820 -2970 {lab=VSS}
N 1820 -2970 2020 -2970 {lab=VSS}
N 2020 -2970 2030 -2960 {lab=VSS}
N 2030 -2960 2130 -2960 {lab=VSS}
N 2580 -2840 2590 -2850 {lab=col_n[1]}
N 2600 -2840 2610 -2850 {lab=col[1]}
N 2130 -3000 2140 -3010 {lab=VDD}
N 2140 -3010 2340 -3010 {lab=VDD}
N 2340 -3010 2350 -3000 {lab=VDD}
N 2350 -3000 2460 -3000 {lab=VDD}
N 2130 -2980 2140 -2990 {lab=VDD}
N 2140 -2990 2340 -2990 {lab=VDD}
N 2340 -2990 2350 -2980 {lab=VDD}
N 2350 -2980 2460 -2980 {lab=VDD}
N 2130 -2960 2140 -2970 {lab=VSS}
N 2140 -2970 2340 -2970 {lab=VSS}
N 2340 -2970 2350 -2960 {lab=VSS}
N 2350 -2960 2460 -2960 {lab=VSS}
N 2130 -2940 2140 -2950 {lab=#net23}
N 2140 -2950 2340 -2950 {lab=#net23}
N 2340 -2950 2350 -2940 {lab=#net23}
N 2350 -2940 2460 -2940 {lab=#net23}
N 2130 -2920 2140 -2930 {lab=#net24}
N 2140 -2930 2340 -2930 {lab=#net24}
N 2340 -2930 2350 -2920 {lab=#net24}
N 2350 -2920 2460 -2920 {lab=#net24}
N 2930 -2840 2940 -2850 {lab=col_n[2]}
N 2950 -2840 2960 -2850 {lab=col[2]}
N 2460 -3000 2470 -3010 {lab=VDD}
N 2470 -3010 2670 -3010 {lab=VDD}
N 2670 -3010 2680 -3000 {lab=VDD}
N 2680 -3000 2810 -3000 {lab=VDD}
N 2460 -2980 2470 -2990 {lab=VDD}
N 2470 -2990 2670 -2990 {lab=VDD}
N 2670 -2990 2680 -2980 {lab=VDD}
N 2460 -2960 2470 -2970 {lab=VSS}
N 2470 -2970 2670 -2970 {lab=VSS}
N 2670 -2970 2680 -2960 {lab=VSS}
N 2680 -2960 2810 -2960 {lab=VSS}
N 2680 -2980 2810 -2980 {lab=VDD}
N 2460 -2940 2470 -2950 {lab=#net23}
N 2470 -2950 2670 -2950 {lab=#net23}
N 2670 -2950 2680 -2940 {lab=#net23}
N 2680 -2940 2810 -2940 {lab=#net23}
N 2460 -2920 2470 -2930 {lab=#net24}
N 2470 -2930 2670 -2930 {lab=#net24}
N 2670 -2930 2680 -2920 {lab=#net24}
N 2680 -2920 2810 -2920 {lab=#net24}
N 3280 -2840 3290 -2850 {lab=col_n[3]}
N 3300 -2840 3310 -2850 {lab=col[3]}
N 2810 -3000 2820 -3010 {lab=VDD}
N 2820 -3010 3020 -3010 {lab=VDD}
N 3020 -3010 3030 -3000 {lab=VDD}
N 3030 -3000 3160 -3000 {lab=VDD}
N 2810 -2980 2820 -2990 {lab=VDD}
N 2820 -2990 3020 -2990 {lab=VDD}
N 3020 -2990 3030 -2980 {lab=VDD}
N 3030 -2980 3160 -2980 {lab=VDD}
N 2810 -2960 2820 -2970 {lab=VSS}
N 2820 -2970 3020 -2970 {lab=VSS}
N 3020 -2970 3030 -2960 {lab=VSS}
N 3030 -2960 3160 -2960 {lab=VSS}
N 2810 -2940 2820 -2950 {lab=#net23}
N 2820 -2950 3020 -2950 {lab=#net23}
N 3020 -2950 3030 -2940 {lab=#net23}
N 3030 -2940 3160 -2940 {lab=#net23}
N 2810 -2920 2820 -2930 {lab=#net24}
N 2820 -2930 3020 -2930 {lab=#net24}
N 3020 -2930 3030 -2920 {lab=#net24}
N 3030 -2920 3160 -2920 {lab=#net24}
N 3630 -2840 3640 -2850 {lab=col_n[4]}
N 3650 -2840 3660 -2850 {lab=col[4]}
N 3160 -3000 3170 -3010 {lab=VDD}
N 3170 -3010 3370 -3010 {lab=VDD}
N 3370 -3010 3380 -3000 {lab=VDD}
N 3380 -3000 3510 -3000 {lab=VDD}
N 3160 -2980 3170 -2990 {lab=VDD}
N 3170 -2990 3370 -2990 {lab=VDD}
N 3370 -2990 3380 -2980 {lab=VDD}
N 3380 -2980 3510 -2980 {lab=VDD}
N 3160 -2960 3170 -2970 {lab=VSS}
N 3170 -2970 3370 -2970 {lab=VSS}
N 3370 -2970 3380 -2960 {lab=VSS}
N 3380 -2960 3510 -2960 {lab=VSS}
N 3160 -2940 3170 -2950 {lab=#net23}
N 3170 -2950 3370 -2950 {lab=#net23}
N 3370 -2950 3380 -2940 {lab=#net23}
N 3380 -2940 3510 -2940 {lab=#net23}
N 3160 -2920 3170 -2930 {lab=#net24}
N 3170 -2930 3370 -2930 {lab=#net24}
N 3370 -2930 3380 -2920 {lab=#net24}
N 3380 -2920 3510 -2920 {lab=#net24}
N 3510 -3000 3520 -3010 {lab=VDD}
N 3520 -3010 3720 -3010 {lab=VDD}
N 3720 -3010 3730 -3000 {lab=VDD}
N 3730 -3000 3850 -3000 {lab=VDD}
N 3510 -2980 3520 -2990 {lab=VDD}
N 3520 -2990 3720 -2990 {lab=VDD}
N 3720 -2990 3730 -2980 {lab=VDD}
N 3730 -2980 3850 -2980 {lab=VDD}
N 3510 -2960 3520 -2970 {lab=VSS}
N 3520 -2970 3720 -2970 {lab=VSS}
N 3720 -2970 3730 -2960 {lab=VSS}
N 3730 -2960 3850 -2960 {lab=VSS}
N 3510 -2940 3520 -2950 {lab=#net23}
N 3520 -2950 3720 -2950 {lab=#net23}
N 3720 -2950 3730 -2940 {lab=#net23}
N 3730 -2940 3850 -2940 {lab=#net23}
N 3510 -2920 3520 -2930 {lab=#net24}
N 3520 -2930 3720 -2930 {lab=#net24}
N 3720 -2930 3730 -2920 {lab=#net24}
N 3730 -2920 3850 -2920 {lab=#net24}
N 3970 -2840 3980 -2850 {lab=col_n[5]}
N 3990 -2840 4000 -2850 {lab=col[5]}
N 3850 -3000 3860 -3010 {lab=VDD}
N 3860 -3010 4060 -3010 {lab=VDD}
N 4060 -3010 4070 -3000 {lab=VDD}
N 4070 -3000 4200 -3000 {lab=VDD}
N 3860 -2990 4060 -2990 {lab=VDD}
N 4060 -2990 4070 -2980 {lab=VDD}
N 4070 -2980 4200 -2980 {lab=VDD}
N 3860 -2970 4060 -2970 {lab=VSS}
N 4060 -2970 4070 -2960 {lab=VSS}
N 4070 -2960 4200 -2960 {lab=VSS}
N 3860 -2950 4060 -2950 {lab=#net23}
N 4060 -2950 4070 -2940 {lab=#net23}
N 4070 -2940 4200 -2940 {lab=#net23}
N 3860 -2930 4060 -2930 {lab=#net24}
N 4060 -2930 4070 -2920 {lab=#net24}
N 4070 -2920 4200 -2920 {lab=#net24}
N 3850 -2980 3860 -2990 {lab=VDD}
N 3850 -2960 3860 -2970 {lab=VSS}
N 3850 -2940 3860 -2950 {lab=#net23}
N 3850 -2920 3860 -2930 {lab=#net24}
N 4200 -3000 4210 -3010 {lab=VDD}
N 4210 -3010 4410 -3010 {lab=VDD}
N 4410 -3010 4420 -3000 {lab=VDD}
N 4420 -3000 4560 -3000 {lab=VDD}
N 4200 -2980 4210 -2990 {lab=VDD}
N 4210 -2990 4410 -2990 {lab=VDD}
N 4410 -2990 4420 -2980 {lab=VDD}
N 4420 -2980 4560 -2980 {lab=VDD}
N 4200 -2960 4210 -2970 {lab=VSS}
N 4210 -2970 4410 -2970 {lab=VSS}
N 4410 -2970 4420 -2960 {lab=VSS}
N 4420 -2960 4560 -2960 {lab=VSS}
N 4200 -2940 4210 -2950 {lab=#net23}
N 4210 -2950 4410 -2950 {lab=#net23}
N 4410 -2950 4420 -2940 {lab=#net23}
N 4420 -2940 4560 -2940 {lab=#net23}
N 4200 -2920 4210 -2930 {lab=#net24}
N 4210 -2930 4410 -2930 {lab=#net24}
N 4410 -2930 4420 -2920 {lab=#net24}
N 4420 -2920 4560 -2920 {lab=#net24}
N 4320 -2840 4330 -2850 {lab=col_n[6]}
N 4340 -2840 4350 -2850 {lab=col[6]}
N 4680 -2840 4690 -2850 {lab=col_n[7]}
N 4700 -2840 4710 -2850 {lab=col[7]}
N 4560 -3000 4570 -3010 {lab=VDD}
N 4570 -3010 4770 -3010 {lab=VDD}
N 4770 -3010 4780 -3000 {lab=VDD}
N 4780 -3000 4890 -3000 {lab=VDD}
N 4560 -2980 4570 -2990 {lab=VDD}
N 4570 -2990 4770 -2990 {lab=VDD}
N 4770 -2990 4780 -2980 {lab=VDD}
N 4780 -2980 4890 -2980 {lab=VDD}
N 4560 -2960 4570 -2970 {lab=VSS}
N 4570 -2970 4770 -2970 {lab=VSS}
N 4770 -2970 4780 -2960 {lab=VSS}
N 4780 -2960 4890 -2960 {lab=VSS}
N 4560 -2940 4570 -2950 {lab=#net23}
N 4570 -2950 4770 -2950 {lab=#net23}
N 4770 -2950 4780 -2940 {lab=#net23}
N 4780 -2940 4890 -2940 {lab=#net23}
N 4560 -2920 4570 -2930 {lab=#net24}
N 4570 -2930 4770 -2930 {lab=#net24}
N 4770 -2930 4780 -2920 {lab=#net24}
N 4780 -2920 4890 -2920 {lab=#net24}
N 4890 -3000 4900 -3010 {lab=VDD}
N 4900 -3010 5100 -3010 {lab=VDD}
N 5100 -3010 5110 -3000 {lab=VDD}
N 5110 -3000 5220 -3000 {lab=VDD}
N 5010 -2840 5020 -2850 {lab=col_n[8]}
N 5030 -2840 5040 -2850 {lab=col[8]}
N 4890 -2980 4900 -2990 {lab=VDD}
N 4900 -2990 5100 -2990 {lab=VDD}
N 5100 -2990 5110 -2980 {lab=VDD}
N 5110 -2980 5220 -2980 {lab=VDD}
N 4890 -2960 4900 -2970 {lab=VSS}
N 4900 -2970 5100 -2970 {lab=VSS}
N 5100 -2970 5110 -2960 {lab=VSS}
N 5110 -2960 5220 -2960 {lab=VSS}
N 4890 -2940 4900 -2950 {lab=#net23}
N 4900 -2950 5100 -2950 {lab=#net23}
N 5100 -2950 5110 -2940 {lab=#net23}
N 5110 -2940 5220 -2940 {lab=#net23}
N 4890 -2920 4900 -2930 {lab=#net24}
N 4900 -2930 5100 -2930 {lab=#net24}
N 5100 -2930 5110 -2920 {lab=#net24}
N 5110 -2920 5220 -2920 {lab=#net24}
N 5340 -2840 5350 -2850 {lab=col_n[9]}
N 5360 -2840 5370 -2850 {lab=col[9]}
N 5220 -3000 5230 -3010 {lab=VDD}
N 5230 -3010 5430 -3010 {lab=VDD}
N 5430 -3010 5440 -3000 {lab=VDD}
N 5440 -3000 5570 -3000 {lab=VDD}
N 5220 -2980 5230 -2990 {lab=VDD}
N 5230 -2990 5430 -2990 {lab=VDD}
N 5430 -2990 5440 -2980 {lab=VDD}
N 5440 -2980 5570 -2980 {lab=VDD}
N 5220 -2960 5230 -2970 {lab=VSS}
N 5230 -2970 5430 -2970 {lab=VSS}
N 5430 -2970 5440 -2960 {lab=VSS}
N 5440 -2960 5570 -2960 {lab=VSS}
N 5230 -2950 5430 -2950 {lab=#net23}
N 5430 -2950 5440 -2940 {lab=#net23}
N 5440 -2940 5570 -2940 {lab=#net23}
N 5230 -2930 5430 -2930 {lab=#net24}
N 5430 -2930 5440 -2920 {lab=#net24}
N 5440 -2920 5570 -2920 {lab=#net24}
N 5220 -2940 5230 -2950 {lab=#net23}
N 5220 -2920 5230 -2930 {lab=#net24}
N 5580 -3010 5780 -3010 {lab=VDD}
N 5780 -3010 5790 -3000 {lab=VDD}
N 5790 -3000 5920 -3000 {lab=VDD}
N 5580 -2990 5780 -2990 {lab=VDD}
N 5780 -2990 5790 -2980 {lab=VDD}
N 5790 -2980 5920 -2980 {lab=VDD}
N 5580 -2970 5780 -2970 {lab=VSS}
N 5780 -2970 5790 -2960 {lab=VSS}
N 5790 -2960 5920 -2960 {lab=VSS}
N 5580 -2950 5780 -2950 {lab=#net23}
N 5780 -2950 5790 -2940 {lab=#net23}
N 5790 -2940 5920 -2940 {lab=#net23}
N 5580 -2930 5780 -2930 {lab=#net24}
N 5780 -2930 5790 -2920 {lab=#net24}
N 5790 -2920 5920 -2920 {lab=#net24}
N 5690 -2840 5700 -2850 {lab=col_n[10]}
N 5710 -2840 5720 -2850 {lab=col[10]}
N 5570 -3000 5580 -3010 {lab=VDD}
N 5570 -2980 5580 -2990 {lab=VDD}
N 5570 -2960 5580 -2970 {lab=VSS}
N 5570 -2940 5580 -2950 {lab=#net23}
N 5570 -2920 5580 -2930 {lab=#net24}
N 6060 -2840 6070 -2850 {lab=col[11]}
N 6040 -2840 6050 -2850 {lab=col_n[11]}
N 5920 -3000 5930 -3010 {lab=VDD}
N 5930 -3010 6130 -3010 {lab=VDD}
N 6130 -3010 6140 -3000 {lab=VDD}
N 6140 -3000 6260 -3000 {lab=VDD}
N 5930 -2990 6130 -2990 {lab=VDD}
N 6130 -2990 6140 -2980 {lab=VDD}
N 6140 -2980 6260 -2980 {lab=VDD}
N 5930 -2970 6130 -2970 {lab=VSS}
N 6130 -2970 6140 -2960 {lab=VSS}
N 6140 -2960 6260 -2960 {lab=VSS}
N 5930 -2950 6130 -2950 {lab=#net23}
N 6130 -2950 6140 -2940 {lab=#net23}
N 6140 -2940 6260 -2940 {lab=#net23}
N 5930 -2930 6130 -2930 {lab=#net24}
N 6130 -2930 6140 -2920 {lab=#net24}
N 6140 -2920 6260 -2920 {lab=#net24}
N 5920 -2980 5930 -2990 {lab=VDD}
N 5920 -2960 5930 -2970 {lab=VSS}
N 5920 -2940 5930 -2950 {lab=#net23}
N 5920 -2920 5930 -2930 {lab=#net24}
N 6260 -3000 6270 -3010 {lab=VDD}
N 6270 -3010 6470 -3010 {lab=VDD}
N 6470 -3010 6480 -3000 {lab=VDD}
N 6480 -3000 6600 -3000 {lab=VDD}
N 6270 -2990 6470 -2990 {lab=VDD}
N 6470 -2990 6480 -2980 {lab=VDD}
N 6480 -2980 6600 -2980 {lab=VDD}
N 6270 -2970 6470 -2970 {lab=VSS}
N 6470 -2970 6480 -2960 {lab=VSS}
N 6480 -2960 6600 -2960 {lab=VSS}
N 6270 -2950 6470 -2950 {lab=#net23}
N 6470 -2950 6480 -2940 {lab=#net23}
N 6480 -2940 6600 -2940 {lab=#net23}
N 6270 -2930 6470 -2930 {lab=#net24}
N 6470 -2930 6480 -2920 {lab=#net24}
N 6480 -2920 6600 -2920 {lab=#net24}
N 6380 -2840 6390 -2850 {lab=col_n[12]}
N 6400 -2840 6410 -2850 {lab=col[12]}
N 6260 -2980 6270 -2990 {lab=VDD}
N 6260 -2960 6270 -2970 {lab=VSS}
N 6260 -2940 6270 -2950 {lab=#net23}
N 6260 -2920 6270 -2930 {lab=#net24}
N 6600 -3000 6610 -3010 {lab=VDD}
N 6610 -3010 6810 -3010 {lab=VDD}
N 6810 -3010 6820 -3000 {lab=VDD}
N 6610 -2990 6810 -2990 {lab=VDD}
N 6810 -2990 6820 -2980 {lab=VDD}
N 6610 -2970 6810 -2970 {lab=VSS}
N 6810 -2970 6820 -2960 {lab=VSS}
N 6610 -2950 6810 -2950 {lab=#net23}
N 6810 -2950 6820 -2940 {lab=#net23}
N 6610 -2930 6810 -2930 {lab=#net24}
N 6810 -2930 6820 -2920 {lab=#net24}
N 6600 -2980 6610 -2990 {lab=VDD}
N 6600 -2960 6610 -2970 {lab=VSS}
N 6600 -2940 6610 -2950 {lab=#net23}
N 6600 -2920 6610 -2930 {lab=#net24}
N 6740 -6410 6750 -6420 {lab=VSS}
N 6750 -6620 6750 -6420 {lab=VSS}
N 6740 -6630 6750 -6620 {lab=VSS}
N 6740 -6650 6740 -6630 {lab=VSS}
N 6720 -6410 6730 -6420 {lab=VDD}
N 6730 -6620 6730 -6420 {lab=VDD}
N 6720 -6630 6730 -6620 {lab=VDD}
N 6720 -6650 6720 -6630 {lab=VDD}
N 6400 -6410 6410 -6420 {lab=col[12]}
N 6410 -6620 6410 -6420 {lab=col[12]}
N 6400 -6630 6410 -6620 {lab=col[12]}
N 6400 -6650 6400 -6630 {lab=col[12]}
N 6380 -6410 6390 -6420 {lab=col_n[12]}
N 6390 -6620 6390 -6420 {lab=col_n[12]}
N 6380 -6630 6390 -6620 {lab=col_n[12]}
N 6380 -6650 6380 -6630 {lab=col_n[12]}
N 6060 -6410 6070 -6420 {lab=col[11]}
N 6070 -6620 6070 -6420 {lab=col[11]}
N 6060 -6630 6070 -6620 {lab=col[11]}
N 6060 -6650 6060 -6630 {lab=col[11]}
N 6040 -6410 6050 -6420 {lab=col_n[11]}
N 6050 -6620 6050 -6420 {lab=col_n[11]}
N 6040 -6630 6050 -6620 {lab=col_n[11]}
N 6040 -6650 6040 -6630 {lab=col_n[11]}
N 5710 -6410 5720 -6420 {lab=col[10]}
N 5720 -6620 5720 -6420 {lab=col[10]}
N 5710 -6630 5720 -6620 {lab=col[10]}
N 5710 -6650 5710 -6630 {lab=col[10]}
N 5690 -6410 5700 -6420 {lab=col_n[10]}
N 5700 -6620 5700 -6420 {lab=col_n[10]}
N 5690 -6630 5700 -6620 {lab=col_n[10]}
N 5690 -6650 5690 -6630 {lab=col_n[10]}
N 5360 -6410 5370 -6420 {lab=col[9]}
N 5370 -6620 5370 -6420 {lab=col[9]}
N 5360 -6630 5370 -6620 {lab=col[9]}
N 5360 -6650 5360 -6630 {lab=col[9]}
N 5340 -6410 5350 -6420 {lab=col_n[9]}
N 5350 -6620 5350 -6420 {lab=col_n[9]}
N 5340 -6630 5350 -6620 {lab=col_n[9]}
N 5340 -6650 5340 -6630 {lab=col_n[9]}
N 5030 -6410 5040 -6420 {lab=col[8]}
N 5040 -6620 5040 -6420 {lab=col[8]}
N 5030 -6630 5040 -6620 {lab=col[8]}
N 5030 -6650 5030 -6630 {lab=col[8]}
N 5010 -6410 5020 -6420 {lab=col_n[8]}
N 5020 -6620 5020 -6420 {lab=col_n[8]}
N 5010 -6630 5020 -6620 {lab=col_n[8]}
N 5010 -6650 5010 -6630 {lab=col_n[8]}
N 4700 -6410 4710 -6420 {lab=col[7]}
N 4710 -6620 4710 -6420 {lab=col[7]}
N 4700 -6630 4710 -6620 {lab=col[7]}
N 4700 -6650 4700 -6630 {lab=col[7]}
N 4680 -6410 4690 -6420 {lab=col_n[7]}
N 4690 -6620 4690 -6420 {lab=col_n[7]}
N 4680 -6630 4690 -6620 {lab=col_n[7]}
N 4680 -6650 4680 -6630 {lab=col_n[7]}
N 4340 -6410 4350 -6420 {lab=col[6]}
N 4350 -6620 4350 -6420 {lab=col[6]}
N 4340 -6630 4350 -6620 {lab=col[6]}
N 4340 -6650 4340 -6630 {lab=col[6]}
N 4320 -6410 4330 -6420 {lab=col_n[6]}
N 4330 -6620 4330 -6420 {lab=col_n[6]}
N 4320 -6630 4330 -6620 {lab=col_n[6]}
N 4320 -6650 4320 -6630 {lab=col_n[6]}
N 3990 -6410 4000 -6420 {lab=col[5]}
N 4000 -6620 4000 -6420 {lab=col[5]}
N 3990 -6630 4000 -6620 {lab=col[5]}
N 3990 -6650 3990 -6630 {lab=col[5]}
N 3970 -6410 3980 -6420 {lab=col_n[5]}
N 3980 -6620 3980 -6420 {lab=col_n[5]}
N 3970 -6630 3980 -6620 {lab=col_n[5]}
N 3970 -6650 3970 -6630 {lab=col_n[5]}
N 3650 -6410 3660 -6420 {lab=col[4]}
N 3660 -6620 3660 -6420 {lab=col[4]}
N 3650 -6630 3660 -6620 {lab=col[4]}
N 3650 -6650 3650 -6630 {lab=col[4]}
N 3630 -6410 3640 -6420 {lab=col_n[4]}
N 3640 -6620 3640 -6420 {lab=col_n[4]}
N 3630 -6630 3640 -6620 {lab=col_n[4]}
N 3630 -6650 3630 -6630 {lab=col_n[4]}
N 3300 -6410 3310 -6420 {lab=col[3]}
N 3310 -6620 3310 -6420 {lab=col[3]}
N 3300 -6630 3310 -6620 {lab=col[3]}
N 3300 -6650 3300 -6630 {lab=col[3]}
N 3280 -6410 3290 -6420 {lab=col_n[3]}
N 3290 -6620 3290 -6420 {lab=col_n[3]}
N 3280 -6630 3290 -6620 {lab=col_n[3]}
N 3280 -6650 3280 -6630 {lab=col_n[3]}
N 2950 -6410 2960 -6420 {lab=col[2]}
N 2960 -6620 2960 -6420 {lab=col[2]}
N 2950 -6630 2960 -6620 {lab=col[2]}
N 2950 -6650 2950 -6630 {lab=col[2]}
N 2930 -6410 2940 -6420 {lab=col_n[2]}
N 2940 -6620 2940 -6420 {lab=col_n[2]}
N 2930 -6630 2940 -6620 {lab=col_n[2]}
N 2930 -6650 2930 -6630 {lab=col_n[2]}
N 2600 -6410 2610 -6420 {lab=col[1]}
N 2610 -6620 2610 -6420 {lab=col[1]}
N 2600 -6630 2610 -6620 {lab=col[1]}
N 2600 -6650 2600 -6630 {lab=col[1]}
N 2580 -6410 2590 -6420 {lab=col_n[1]}
N 2590 -6620 2590 -6420 {lab=col_n[1]}
N 2580 -6630 2590 -6620 {lab=col_n[1]}
N 2580 -6650 2580 -6630 {lab=col_n[1]}
N 2270 -6410 2280 -6420 {lab=col[0]}
N 2280 -6620 2280 -6420 {lab=col[0]}
N 2270 -6630 2280 -6620 {lab=col[0]}
N 2270 -6650 2270 -6630 {lab=col[0]}
N 2250 -6410 2260 -6420 {lab=col_n[0]}
N 2260 -6620 2260 -6420 {lab=col_n[0]}
N 2250 -6630 2260 -6620 {lab=col_n[0]}
N 2250 -6650 2250 -6630 {lab=col_n[0]}
N 1950 -6410 1960 -6420 {lab=VSS}
N 1960 -6620 1960 -6420 {lab=VSS}
N 1950 -6630 1960 -6620 {lab=VSS}
N 1950 -6650 1950 -6630 {lab=VSS}
N 1930 -6410 1940 -6420 {lab=VDD}
N 1940 -6620 1940 -6420 {lab=VDD}
N 1930 -6630 1940 -6620 {lab=VDD}
N 1930 -6650 1930 -6630 {lab=VDD}
N 3980 -1830 3980 -1810 {lab=GND}
N 3980 -1970 3980 -1950 {lab=VDD}
N 3870 -1890 3920 -1890 {lab=#net25}
N 4040 -1890 4120 -1890 {lab=vcm}
N 4290 -1830 4290 -1800 {lab=GND}
N 4190 -1830 4190 -1800 {lab=GND}
N 3870 -1830 3870 -1810 {lab=GND}
N 3740 -2020 3740 -2000 {
lab=VDD}
N 3740 -1940 3740 -1920 {
lab=GND}
N 3730 -1550 3800 -1550 {lab=VDD}
N 3800 -1560 3800 -1550 {lab=VDD}
N 3800 -1560 3830 -1560 {lab=VDD}
N 3720 -1500 3830 -1500 {lab=GND}
N 3720 -1500 3720 -1450 {lab=GND}
N 3720 -1450 3720 -1430 {lab=GND}
N 3380 -1830 3380 -1740 {lab=#net26}
N 4120 -1890 4320 -1890 {lab=vcm}
N 4130 -1540 4250 -1540 {lab=analog_in}
N 3710 -1540 3830 -1540 {lab=sample}
N 3710 -1520 3830 -1520 {lab=sample_n}
N 3890 -1290 3890 -1270 {lab=GND}
N 3100 -1880 3100 -1830 {lab=sw}
N 3100 -1770 3100 -1750 {lab=GND}
N 3100 -1570 3100 -1540 {lab=sw_n}
N 3100 -1480 3100 -1460 {lab=GND}
N 2380 -2000 2380 -1960 {lab=row_n[0]}
N 2380 -1900 2380 -1870 {lab=GND}
N 2380 -1790 2380 -1750 {lab=row_n[1]}
N 2380 -1690 2380 -1660 {lab=GND}
N 2380 -1580 2380 -1540 {lab=row_n[2]}
N 2380 -1480 2380 -1450 {lab=GND}
N 2380 -1360 2380 -1320 {lab=row_n[3]}
N 2380 -1260 2380 -1230 {lab=GND}
N 2380 -1150 2380 -1110 {lab=row_n[4]}
N 2380 -1050 2380 -1020 {lab=GND}
N 2580 -2000 2580 -1960 {lab=row_n[5]}
N 2580 -1900 2580 -1870 {lab=GND}
N 2580 -1800 2580 -1760 {lab=row_n[6]}
N 2580 -1700 2580 -1670 {lab=GND}
N 2580 -1590 2580 -1550 {lab=row_n[7]}
N 2580 -1490 2580 -1460 {lab=GND}
N 2580 -1360 2580 -1320 {lab=row_n[8]}
N 2580 -1260 2580 -1230 {lab=GND}
N 2580 -1150 2580 -1110 {lab=row_n[9]}
N 2580 -1050 2580 -1020 {lab=GND}
N 1870 -2000 1870 -1960 {lab=rowon_n[0]}
N 1870 -1900 1870 -1870 {lab=GND}
N 1870 -1790 1870 -1750 {lab=rowon_n[1]}
N 1870 -1690 1870 -1660 {lab=GND}
N 1870 -1580 1870 -1540 {lab=rowon_n[2]}
N 1870 -1480 1870 -1450 {lab=GND}
N 1870 -1360 1870 -1320 {lab=rowon_n[3]}
N 1870 -1260 1870 -1230 {lab=GND}
N 1870 -1150 1870 -1110 {lab=rowon_n[4]}
N 1870 -1050 1870 -1020 {lab=GND}
N 2070 -2000 2070 -1960 {lab=rowon_n[5]}
N 2070 -1900 2070 -1870 {lab=GND}
N 2070 -1800 2070 -1760 {lab=rowon_n[6]}
N 2070 -1700 2070 -1670 {lab=GND}
N 2070 -1590 2070 -1550 {lab=rowon_n[7]}
N 2070 -1490 2070 -1460 {lab=GND}
N 2070 -1360 2070 -1320 {lab=rowon_n[8]}
N 2070 -1260 2070 -1230 {lab=GND}
N 2070 -1150 2070 -1110 {lab=rowon_n[9]}
N 2070 -1050 2070 -1020 {lab=GND}
N 1340 -1990 1340 -1950 {lab=rowoff_n[0]}
N 1340 -1890 1340 -1860 {lab=GND}
N 1340 -1780 1340 -1740 {lab=rowoff_n[1]}
N 1340 -1680 1340 -1650 {lab=GND}
N 1340 -1570 1340 -1530 {lab=rowoff_n[2]}
N 1340 -1470 1340 -1440 {lab=GND}
N 1340 -1350 1340 -1310 {lab=rowoff_n[3]}
N 1340 -1250 1340 -1220 {lab=GND}
N 1340 -1140 1340 -1100 {lab=rowoff_n[4]}
N 1340 -1040 1340 -1010 {lab=GND}
N 1540 -1990 1540 -1950 {lab=rowoff_n[5]}
N 1540 -1890 1540 -1860 {lab=GND}
N 1540 -1790 1540 -1750 {lab=rowoff_n[6]}
N 1540 -1690 1540 -1660 {lab=GND}
N 1540 -1580 1540 -1540 {lab=rowoff_n[7]}
N 1540 -1480 1540 -1450 {lab=GND}
N 1540 -1350 1540 -1310 {lab=rowoff_n[8]}
N 1540 -1250 1540 -1220 {lab=GND}
N 1540 -1140 1540 -1100 {lab=rowoff_n[9]}
N 1540 -1040 1540 -1010 {lab=GND}
N 1340 -850 1340 -820 {lab=col_n[0]}
N 1340 -760 1340 -740 {lab=GND}
N 1340 -690 1340 -660 {lab=col_n[1]}
N 1340 -600 1340 -580 {lab=GND}
N 1340 -520 1340 -490 {lab=col_n[2]}
N 1340 -430 1340 -410 {lab=GND}
N 1340 -360 1340 -330 {lab=col_n[3]}
N 1340 -270 1340 -250 {lab=GND}
N 1540 -860 1540 -830 {lab=col_n[4]}
N 1540 -770 1540 -750 {lab=GND}
N 1540 -700 1540 -670 {lab=col_n[5]}
N 1540 -610 1540 -590 {lab=GND}
N 1540 -530 1540 -500 {lab=col_n[6]}
N 1540 -440 1540 -420 {lab=GND}
N 1540 -370 1540 -340 {lab=col_n[7]}
N 1540 -280 1540 -260 {lab=GND}
N 1750 -860 1750 -830 {lab=col_n[8]}
N 1750 -770 1750 -750 {lab=GND}
N 1750 -700 1750 -670 {lab=col_n[9]}
N 1750 -610 1750 -590 {lab=GND}
N 1750 -530 1750 -500 {lab=col_n[10]}
N 1750 -440 1750 -420 {lab=GND}
N 1750 -370 1750 -340 {lab=col_n[11]}
N 1750 -280 1750 -260 {lab=GND}
N 1530 -180 1530 -150 {lab=col_n[12]}
N 1530 -90 1530 -70 {lab=GND}
N 1920 -860 1920 -840 {lab=col[0]}
N 1920 -780 1920 -760 {lab=GND}
N 1920 -710 1920 -690 {lab=col[1]}
N 1920 -630 1920 -610 {lab=GND}
N 1920 -560 1920 -540 {lab=col[2]}
N 1920 -480 1920 -460 {lab=GND}
N 1920 -400 1920 -380 {lab=col[3]}
N 1920 -320 1920 -300 {lab=GND}
N 2040 -870 2040 -850 {lab=col[4]}
N 2040 -790 2040 -770 {lab=GND}
N 2040 -710 2040 -690 {lab=col[5]}
N 2040 -630 2040 -610 {lab=GND}
N 2040 -550 2040 -530 {lab=col[6]}
N 2040 -470 2040 -450 {lab=GND}
N 2030 -400 2030 -380 {lab=col[7]}
N 2030 -320 2030 -300 {lab=GND}
N 2170 -890 2170 -870 {lab=col[8]}
N 2170 -810 2170 -790 {lab=GND}
N 2160 -720 2160 -700 {lab=col[9]}
N 2160 -640 2160 -620 {lab=GND}
N 2160 -550 2160 -530 {lab=col[10]}
N 2160 -470 2160 -450 {lab=GND}
N 2160 -390 2160 -370 {lab=col[11]}
N 2160 -310 2160 -290 {lab=GND}
N 2280 -730 2280 -710 {lab=col[12]}
N 2280 -650 2280 -630 {lab=GND}
N 3030 -1150 3030 -1120 {lab=GND}
N 3180 -1150 3180 -1120 {lab=GND}
N 3320 -1150 3320 -1120 {lab=GND}
N 3030 -1230 3030 -1210 {lab=en_bit_n[0]}
N 3180 -1230 3180 -1210 {lab=en_bit_n[1]}
N 3320 -1230 3320 -1210 {lab=en_bit_n[2]}
N 3490 -1150 3490 -1120 {lab=GND}
N 3490 -1240 3490 -1210 {lab=en_C0_n}
C {adc_sar_wafflecap_drv.sym} 1570 -2790 0 0 {name=x2}
C {adc_sar_wafflecap_dummy.sym} 1930 -2750 0 0 {name=x1}
C {adc_sar_wafflecap_8_1.sym} 2030 -2730 0 0 {name=x3}
C {adc_sar_wafflecap_dummy.sym} 2610 -2750 0 0 {name=x4}
C {adc_sar_wafflecap_dummy.sym} 2960 -2750 0 0 {name=x5}
C {adc_sar_wafflecap_dummy.sym} 3310 -2750 0 0 {name=x6}
C {adc_sar_wafflecap_dummy.sym} 3650 -2750 0 0 {name=x7}
C {adc_sar_wafflecap_dummy.sym} 5020 -2750 0 0 {name=x11}
C {adc_sar_wafflecap_dummy.sym} 5370 -2750 0 0 {name=x12}
C {adc_sar_wafflecap_dummy.sym} 5720 -2750 0 0 {name=x13}
C {adc_sar_wafflecap_8_2.sym} 4140 -2670 0 0 {name=x8}
C {adc_sar_wafflecap_8_4.sym} 4220 -2760 0 0 {name=x9}
C {adc_sar_wafflecap_8_1.sym} 4460 -2730 0 0 {name=x10}
C {adc_sar_wafflecap_drv.sym} 1570 -3110 0 0 {name=x17}
C {adc_sar_wafflecap_dummy.sym} 1930 -3070 0 0 {name=x18}
C {adc_sar_wafflecap_dummy.sym} 2260 -3070 0 0 {name=x19}
C {adc_sar_wafflecap_dummy.sym} 2610 -3070 0 0 {name=x20}
C {adc_sar_wafflecap_8_8.sym} 3020 -2990 0 0 {name=x21}
C {adc_sar_wafflecap_8_8.sym} 3370 -2990 0 0 {name=x22}
C {adc_sar_wafflecap_8_8.sym} 3710 -2990 0 0 {name=x23}
C {adc_sar_wafflecap_8_8.sym} 4060 -2990 0 0 {name=x24}
C {adc_sar_wafflecap_8_8.sym} 4420 -2990 0 0 {name=x25}
C {adc_sar_wafflecap_8_8.sym} 4750 -2990 0 0 {name=x26}
C {adc_sar_wafflecap_8_8.sym} 5080 -2990 0 0 {name=x27}
C {adc_sar_wafflecap_dummy.sym} 5370 -3070 0 0 {name=x28}
C {adc_sar_wafflecap_dummy.sym} 5720 -3070 0 0 {name=x29}
C {adc_sar_wafflecap_dummy.sym} 6060 -3070 0 0 {name=x30}
C {adc_sar_wafflecap_dummy.sym} 6400 -3070 0 0 {name=x31}
C {adc_sar_wafflecap_drv.sym} 1570 -3410 0 0 {name=x33}
C {adc_sar_wafflecap_8_8.sym} 1990 -3290 0 0 {name=x34}
C {adc_sar_wafflecap_8_8.sym} 2320 -3290 0 0 {name=x35}
C {adc_sar_wafflecap_8_8.sym} 2670 -3290 0 0 {name=x36}
C {adc_sar_wafflecap_8_8.sym} 3020 -3290 0 0 {name=x37}
C {adc_sar_wafflecap_8_8.sym} 3370 -3290 0 0 {name=x38}
C {adc_sar_wafflecap_8_8.sym} 3710 -3290 0 0 {name=x39}
C {adc_sar_wafflecap_8_8.sym} 4060 -3290 0 0 {name=x40}
C {adc_sar_wafflecap_8_8.sym} 4420 -3290 0 0 {name=x41}
C {adc_sar_wafflecap_8_8.sym} 4750 -3290 0 0 {name=x42}
C {adc_sar_wafflecap_8_8.sym} 5080 -3290 0 0 {name=x43}
C {adc_sar_wafflecap_8_8.sym} 5430 -3290 0 0 {name=x44}
C {adc_sar_wafflecap_8_8.sym} 5780 -3290 0 0 {name=x45}
C {adc_sar_wafflecap_8_8.sym} 6120 -3290 0 0 {name=x46}
C {devices/lab_wire.sym} 1790 -2960 0 0 {name=l2050 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1790 -2980 0 0 {name=l2051 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1790 -3000 0 0 {name=l2058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1790 -2940 0 0 {name=l2111 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -2920 0 0 {name=l2112 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1850 -2830 3 0 {name=l4354 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1930 -2830 3 0 {name=l4358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1950 -2830 3 0 {name=l2057 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -2830 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2250 -2820 3 0 {name=l4363 sig_type=std_logic lab=col_n[0]}
C {devices/lab_wire.sym} 2270 -2820 3 0 {name=l2060 sig_type=std_logic lab=col[0]}
C {devices/lab_wire.sym} 2500 -2830 0 0 {name=l4364 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -2820 3 0 {name=l4367 sig_type=std_logic lab=col_n[1]}
C {devices/lab_wire.sym} 2530 -2820 3 0 {name=l1 sig_type=std_logic lab=en_C0_n}
C {devices/lab_wire.sym} 2600 -2820 3 0 {name=l2061 sig_type=std_logic lab=col[1]}
C {devices/lab_wire.sym} 1850 -3150 3 0 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1850 -3450 3 0 {name=l3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -3450 3 0 {name=l4 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -3150 3 0 {name=l5 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -3150 3 0 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -3450 3 0 {name=l7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -3450 3 0 {name=l8 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -3150 3 0 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -3150 3 0 {name=l10 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -3450 3 0 {name=l11 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -3450 3 0 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -3450 3 0 {name=l13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -3150 3 0 {name=l14 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -3150 3 0 {name=l15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -3450 3 0 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -3150 3 0 {name=l17 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -3450 3 0 {name=l18 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -3450 3 0 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -3150 3 0 {name=l20 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -3150 3 0 {name=l21 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -3150 3 0 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -3450 3 0 {name=l23 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -3450 3 0 {name=l24 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -3450 3 0 {name=l25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -3150 3 0 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -3150 3 0 {name=l27 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -3450 3 0 {name=l28 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -3150 3 0 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -3450 3 0 {name=l30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -3150 3 0 {name=l31 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -2830 0 0 {name=l4374 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3280 -2820 3 0 {name=l4377 sig_type=std_logic lab=col_n[3]}
C {devices/lab_wire.sym} 3300 -2820 3 0 {name=l2063 sig_type=std_logic lab=col[3]}
C {devices/lab_wire.sym} 2850 -2830 0 0 {name=l4368 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2930 -2820 3 0 {name=l4371 sig_type=std_logic lab=col_n[2]}
C {devices/lab_wire.sym} 2950 -2820 3 0 {name=l2062 sig_type=std_logic lab=col[2]}
C {devices/lab_wire.sym} 3550 -2830 0 0 {name=l4378 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3630 -2820 3 0 {name=l4381 sig_type=std_logic lab=col_n[4]}
C {devices/lab_wire.sym} 3650 -2820 3 0 {name=l2064 sig_type=std_logic lab=col[4]}
C {devices/lab_wire.sym} 3890 -2830 0 0 {name=l4384 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3970 -2820 3 0 {name=l4387 sig_type=std_logic lab=col_n[5]}
C {devices/lab_wire.sym} 3990 -2820 3 0 {name=l2065 sig_type=std_logic lab=col[5]}
C {devices/lab_wire.sym} 4240 -2830 0 0 {name=l4434 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4320 -2820 3 0 {name=l4437 sig_type=std_logic lab=col_n[6]}
C {devices/lab_wire.sym} 4270 -2820 3 0 {name=l4797 sig_type=std_logic lab=en_bit_n[1]}
C {devices/lab_wire.sym} 4340 -2820 3 0 {name=l2075 sig_type=std_logic lab=col[6]}
C {devices/lab_wire.sym} 4600 -2830 0 0 {name=l50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4680 -2820 3 0 {name=l51 sig_type=std_logic lab=col_n[7]}
C {devices/lab_wire.sym} 4630 -2820 3 0 {name=l52 sig_type=std_logic lab=en_bit_n[2]}
C {devices/lab_wire.sym} 4700 -2820 3 0 {name=l53 sig_type=std_logic lab=col[7]}
C {devices/lab_wire.sym} 4930 -2830 0 0 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5010 -2820 3 0 {name=l55 sig_type=std_logic lab=col_n[8]}
C {devices/lab_wire.sym} 4960 -2820 3 0 {name=l56 sig_type=std_logic lab=en_bit_n[0]}
C {devices/lab_wire.sym} 5030 -2820 3 0 {name=l57 sig_type=std_logic lab=col[8]}
C {devices/lab_wire.sym} 5340 -2820 3 0 {name=l58 sig_type=std_logic lab=col_n[9]}
C {devices/lab_wire.sym} 5360 -2820 3 0 {name=l59 sig_type=std_logic lab=col[9]}
C {devices/lab_wire.sym} 5260 -2830 0 0 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5690 -2820 3 0 {name=l61 sig_type=std_logic lab=col_n[10]}
C {devices/lab_wire.sym} 5710 -2820 3 0 {name=l62 sig_type=std_logic lab=col[10]}
C {devices/lab_wire.sym} 5610 -2830 0 0 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6040 -2820 3 0 {name=l64 sig_type=std_logic lab=col_n[11]}
C {devices/lab_wire.sym} 6060 -2820 3 0 {name=l65 sig_type=std_logic lab=col[11]}
C {devices/lab_wire.sym} 5960 -2830 0 0 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6380 -2820 3 0 {name=l67 sig_type=std_logic lab=col_n[12]}
C {devices/lab_wire.sym} 6400 -2820 3 0 {name=l68 sig_type=std_logic lab=col[12]}
C {devices/lab_wire.sym} 6300 -2830 0 0 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -2830 0 0 {name=l4514 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6360 -2820 3 0 {name=l2052 sig_type=std_logic lab=sw}
C {devices/lab_wire.sym} 6420 -2820 3 0 {name=l2053 sig_type=std_logic lab=analog_in}
C {devices/lab_wire.sym} 6440 -2820 3 0 {name=l2054 sig_type=std_logic lab=sw_n}
C {devices/lab_wire.sym} 6720 -2820 3 0 {name=l4522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6740 -2820 3 0 {name=l2092 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1850 -3070 2 1 {name=l4509 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -3080 1 1 {name=l70 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -3080 3 0 {name=l71 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -3070 2 1 {name=l72 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -3080 1 1 {name=l73 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -3080 3 0 {name=l74 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -3070 2 1 {name=l75 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -3080 1 1 {name=l76 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -3080 3 0 {name=l77 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -3070 2 1 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -3080 1 1 {name=l79 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -3080 3 0 {name=l80 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3070 2 1 {name=l81 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3080 1 1 {name=l82 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -3080 3 0 {name=l83 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -3070 2 1 {name=l84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -3080 1 1 {name=l85 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -3080 3 0 {name=l86 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -3070 2 1 {name=l87 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -3080 1 1 {name=l88 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -3080 3 0 {name=l89 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3070 2 1 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3080 1 1 {name=l91 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -3080 3 0 {name=l92 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -3070 2 1 {name=l93 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -3080 1 1 {name=l94 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -3080 3 0 {name=l95 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -3070 2 1 {name=l96 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -3080 1 1 {name=l97 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -3080 3 0 {name=l98 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -3070 2 1 {name=l99 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -3080 1 1 {name=l100 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -3080 3 0 {name=l101 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -3070 2 1 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -3080 1 1 {name=l103 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -3080 3 0 {name=l104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -3070 2 1 {name=l105 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -3080 1 1 {name=l106 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -3080 3 0 {name=l107 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -3070 2 1 {name=l108 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -3080 1 1 {name=l109 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -3080 3 0 {name=l110 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6640 -3070 2 1 {name=l111 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -3080 1 1 {name=l112 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -3080 3 0 {name=l113 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6640 -3390 2 1 {name=l120 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -3400 1 1 {name=l121 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -3400 3 0 {name=l122 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6640 -3690 2 1 {name=l123 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -3700 1 1 {name=l124 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -3700 3 0 {name=l125 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -3690 2 1 {name=l141 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -3700 1 1 {name=l142 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -3700 3 0 {name=l143 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -3690 2 1 {name=l144 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -3700 1 1 {name=l145 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -3700 3 0 {name=l146 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -3390 2 1 {name=l147 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -3400 1 1 {name=l148 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -3400 3 0 {name=l149 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -3390 2 1 {name=l150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -3400 1 1 {name=l151 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -3400 3 0 {name=l152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -3390 2 1 {name=l153 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -3400 1 1 {name=l154 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -3400 3 0 {name=l155 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -3690 2 1 {name=l156 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -3700 1 1 {name=l157 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -3700 3 0 {name=l158 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -3690 2 1 {name=l165 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -3700 1 1 {name=l166 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -3700 3 0 {name=l167 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -3390 2 1 {name=l168 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -3400 1 1 {name=l169 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -3400 3 0 {name=l170 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -3390 2 1 {name=l171 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -3400 1 1 {name=l172 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -3400 3 0 {name=l173 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -3690 2 1 {name=l174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -3700 1 1 {name=l175 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -3700 3 0 {name=l176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -3690 2 1 {name=l177 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -3700 1 1 {name=l178 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -3700 3 0 {name=l179 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -3390 2 1 {name=l180 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -3400 1 1 {name=l181 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -3400 3 0 {name=l182 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3390 2 1 {name=l183 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3400 1 1 {name=l184 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -3400 3 0 {name=l185 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3690 2 1 {name=l186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3700 1 1 {name=l187 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -3700 3 0 {name=l188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -3690 2 1 {name=l189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -3700 1 1 {name=l190 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -3700 3 0 {name=l191 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -3390 2 1 {name=l192 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -3400 1 1 {name=l193 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -3400 3 0 {name=l194 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -3390 2 1 {name=l195 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -3400 1 1 {name=l196 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -3400 3 0 {name=l197 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -3690 2 1 {name=l198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -3700 1 1 {name=l199 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -3700 3 0 {name=l200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3690 2 1 {name=l201 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3700 1 1 {name=l202 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -3700 3 0 {name=l203 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3390 2 1 {name=l204 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3400 1 1 {name=l205 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -3400 3 0 {name=l206 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -3390 2 1 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -3400 1 1 {name=l208 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -3400 3 0 {name=l209 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -3690 2 1 {name=l210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -3700 1 1 {name=l211 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -3700 3 0 {name=l212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -3690 2 1 {name=l213 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -3700 1 1 {name=l214 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -3700 3 0 {name=l215 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -3690 2 1 {name=l216 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -3700 1 1 {name=l217 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -3700 3 0 {name=l218 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -3390 2 1 {name=l219 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -3400 1 1 {name=l220 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -3400 3 0 {name=l221 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -3390 2 1 {name=l222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -3400 1 1 {name=l223 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -3400 3 0 {name=l224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -3690 2 1 {name=l225 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -3700 1 1 {name=l226 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -3700 3 0 {name=l227 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -3390 2 1 {name=l228 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -3400 1 1 {name=l229 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -3400 3 0 {name=l230 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1790 -3240 0 0 {name=l4102 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -3300 0 0 {name=l4105 sig_type=std_logic lab=row_n[0]}
C {devices/lab_wire.sym} 1790 -3280 0 0 {name=l4104 sig_type=std_logic lab=rowon_n[0]}
C {devices/lab_wire.sym} 1790 -3260 0 0 {name=l4103 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -3320 0 0 {name=l2093 sig_type=std_logic lab=rowoff_n[0]}
C {devices/lab_wire.sym} 1790 -3540 0 0 {name=l4110 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -3600 0 0 {name=l4111 sig_type=std_logic lab=row_n[1]}
C {devices/lab_wire.sym} 1790 -3580 0 0 {name=l4112 sig_type=std_logic lab=rowon_n[1]}
C {devices/lab_wire.sym} 1790 -3560 0 0 {name=l4113 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -3870 0 0 {name=l4118 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -3930 0 0 {name=l4119 sig_type=std_logic lab=row_n[2]}
C {devices/lab_wire.sym} 1790 -3910 0 0 {name=l4120 sig_type=std_logic lab=rowon_n[2]}
C {devices/lab_wire.sym} 1790 -3890 0 0 {name=l4121 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -3620 0 0 {name=l2094 sig_type=std_logic lab=rowoff_n[1]}
C {devices/lab_wire.sym} 1790 -3950 0 0 {name=l2095 sig_type=std_logic lab=rowoff_n[2]}
C {adc_sar_wafflecap_drv.sym} 1570 -3740 0 0 {name=x49}
C {adc_sar_wafflecap_8_8.sym} 1990 -3620 0 0 {name=x50}
C {adc_sar_wafflecap_8_8.sym} 2320 -3620 0 0 {name=x51}
C {adc_sar_wafflecap_8_8.sym} 2670 -3620 0 0 {name=x52}
C {adc_sar_wafflecap_8_8.sym} 3020 -3620 0 0 {name=x53}
C {adc_sar_wafflecap_8_8.sym} 3370 -3620 0 0 {name=x54}
C {adc_sar_wafflecap_8_8.sym} 3710 -3620 0 0 {name=x55}
C {adc_sar_wafflecap_8_8.sym} 4060 -3620 0 0 {name=x56}
C {adc_sar_wafflecap_8_8.sym} 4420 -3620 0 0 {name=x57}
C {adc_sar_wafflecap_8_8.sym} 4750 -3620 0 0 {name=x58}
C {adc_sar_wafflecap_8_8.sym} 5080 -3620 0 0 {name=x59}
C {adc_sar_wafflecap_8_8.sym} 5430 -3620 0 0 {name=x60}
C {adc_sar_wafflecap_8_8.sym} 5780 -3620 0 0 {name=x61}
C {adc_sar_wafflecap_8_8.sym} 6120 -3620 0 0 {name=x62}
C {devices/lab_wire.sym} 1850 -3780 3 0 {name=l34 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -3780 3 0 {name=l35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -3780 3 0 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -3780 3 0 {name=l37 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -3780 3 0 {name=l38 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -3780 3 0 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -3780 3 0 {name=l40 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -3780 3 0 {name=l41 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -3780 3 0 {name=l42 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -3780 3 0 {name=l43 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -3780 3 0 {name=l44 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -3780 3 0 {name=l45 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -3780 3 0 {name=l46 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -3780 3 0 {name=l47 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -3780 3 0 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -4020 2 1 {name=l129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -4030 1 1 {name=l130 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -4030 3 0 {name=l131 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -4020 2 1 {name=l135 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -4030 1 1 {name=l136 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -4030 3 0 {name=l137 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -4020 2 1 {name=l138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -4030 1 1 {name=l139 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -4030 3 0 {name=l140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -4020 2 1 {name=l159 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -4030 1 1 {name=l160 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -4030 3 0 {name=l161 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -4020 2 1 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -4030 1 1 {name=l163 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -4030 3 0 {name=l164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -4020 2 1 {name=l231 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -4030 1 1 {name=l232 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -4030 3 0 {name=l233 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -4020 2 1 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -4030 1 1 {name=l235 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -4030 3 0 {name=l236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4020 2 1 {name=l237 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4030 1 1 {name=l238 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -4030 3 0 {name=l239 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -4020 2 1 {name=l240 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -4030 1 1 {name=l241 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -4030 3 0 {name=l242 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -4020 2 1 {name=l243 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -4030 1 1 {name=l244 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -4030 3 0 {name=l245 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4020 2 1 {name=l246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4030 1 1 {name=l247 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -4030 3 0 {name=l248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -4020 2 1 {name=l249 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -4030 1 1 {name=l250 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -4030 3 0 {name=l251 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -4020 2 1 {name=l252 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -4030 1 1 {name=l253 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -4030 3 0 {name=l254 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -4020 2 1 {name=l255 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -4030 1 1 {name=l256 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -4030 3 0 {name=l257 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -4020 2 1 {name=l258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -4030 1 1 {name=l259 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -4030 3 0 {name=l260 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 1570 -4060 0 0 {name=x65}
C {adc_sar_wafflecap_8_8.sym} 1990 -3940 0 0 {name=x66}
C {adc_sar_wafflecap_8_8.sym} 2320 -3940 0 0 {name=x67}
C {adc_sar_wafflecap_8_8.sym} 2670 -3940 0 0 {name=x68}
C {adc_sar_wafflecap_8_8.sym} 3020 -3940 0 0 {name=x69}
C {adc_sar_wafflecap_8_8.sym} 3370 -3940 0 0 {name=x70}
C {adc_sar_wafflecap_8_8.sym} 3710 -3940 0 0 {name=x71}
C {adc_sar_wafflecap_8_8.sym} 4060 -3940 0 0 {name=x72}
C {adc_sar_wafflecap_8_8.sym} 4420 -3940 0 0 {name=x73}
C {adc_sar_wafflecap_8_8.sym} 4750 -3940 0 0 {name=x74}
C {adc_sar_wafflecap_8_8.sym} 5080 -3940 0 0 {name=x75}
C {adc_sar_wafflecap_8_8.sym} 5430 -3940 0 0 {name=x76}
C {adc_sar_wafflecap_8_8.sym} 5780 -3940 0 0 {name=x77}
C {adc_sar_wafflecap_8_8.sym} 6120 -3940 0 0 {name=x78}
C {devices/lab_wire.sym} 1850 -4100 3 0 {name=l261 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -4100 3 0 {name=l262 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -4100 3 0 {name=l263 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -4100 3 0 {name=l264 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -4100 3 0 {name=l265 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -4100 3 0 {name=l266 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -4100 3 0 {name=l267 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -4100 3 0 {name=l268 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -4100 3 0 {name=l269 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -4100 3 0 {name=l270 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -4100 3 0 {name=l271 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -4100 3 0 {name=l272 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -4100 3 0 {name=l273 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -4100 3 0 {name=l274 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -4100 3 0 {name=l275 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -4340 2 1 {name=l277 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -4350 1 1 {name=l278 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -4350 3 0 {name=l279 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -4340 2 1 {name=l283 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -4350 1 1 {name=l284 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -4350 3 0 {name=l285 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -4340 2 1 {name=l286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -4350 1 1 {name=l287 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -4350 3 0 {name=l288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -4340 2 1 {name=l289 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -4350 1 1 {name=l290 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -4350 3 0 {name=l291 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -4340 2 1 {name=l292 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -4350 1 1 {name=l293 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -4350 3 0 {name=l294 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -4340 2 1 {name=l295 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -4350 1 1 {name=l296 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -4350 3 0 {name=l297 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -4340 2 1 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -4350 1 1 {name=l299 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -4350 3 0 {name=l300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4340 2 1 {name=l301 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4350 1 1 {name=l302 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -4350 3 0 {name=l303 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -4340 2 1 {name=l304 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -4350 1 1 {name=l305 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -4350 3 0 {name=l306 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -4340 2 1 {name=l307 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -4350 1 1 {name=l308 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -4350 3 0 {name=l309 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4340 2 1 {name=l310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4350 1 1 {name=l311 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -4350 3 0 {name=l312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -4340 2 1 {name=l313 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -4350 1 1 {name=l314 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -4350 3 0 {name=l315 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -4340 2 1 {name=l316 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -4350 1 1 {name=l317 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -4350 3 0 {name=l318 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -4340 2 1 {name=l319 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -4350 1 1 {name=l320 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -4350 3 0 {name=l321 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -4340 2 1 {name=l322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -4350 1 1 {name=l323 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -4350 3 0 {name=l324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1790 -4190 0 0 {name=l325 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -4250 0 0 {name=l326 sig_type=std_logic lab=row_n[3]}
C {devices/lab_wire.sym} 1790 -4230 0 0 {name=l327 sig_type=std_logic lab=rowon_n[3]}
C {devices/lab_wire.sym} 1790 -4210 0 0 {name=l328 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -4520 0 0 {name=l329 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -4580 0 0 {name=l330 sig_type=std_logic lab=row_n[4]}
C {devices/lab_wire.sym} 1790 -4560 0 0 {name=l331 sig_type=std_logic lab=rowon_n[4]}
C {devices/lab_wire.sym} 1790 -4540 0 0 {name=l332 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -4270 0 0 {name=l333 sig_type=std_logic lab=rowoff_n[3]}
C {devices/lab_wire.sym} 1790 -4600 0 0 {name=l334 sig_type=std_logic lab=rowoff_n[4]}
C {adc_sar_wafflecap_drv.sym} 1570 -4390 0 0 {name=x81}
C {adc_sar_wafflecap_8_8.sym} 1990 -4270 0 0 {name=x82}
C {adc_sar_wafflecap_8_8.sym} 2320 -4270 0 0 {name=x83}
C {adc_sar_wafflecap_8_8.sym} 2670 -4270 0 0 {name=x84}
C {adc_sar_wafflecap_8_8.sym} 3020 -4270 0 0 {name=x85}
C {adc_sar_wafflecap_8_8.sym} 3370 -4270 0 0 {name=x86}
C {adc_sar_wafflecap_8_8.sym} 3710 -4270 0 0 {name=x87}
C {adc_sar_wafflecap_8_8.sym} 4060 -4270 0 0 {name=x88}
C {adc_sar_wafflecap_8_8.sym} 4420 -4270 0 0 {name=x89}
C {adc_sar_wafflecap_8_8.sym} 4750 -4270 0 0 {name=x90}
C {adc_sar_wafflecap_8_8.sym} 5080 -4270 0 0 {name=x91}
C {adc_sar_wafflecap_8_8.sym} 5430 -4270 0 0 {name=x92}
C {adc_sar_wafflecap_8_8.sym} 5780 -4270 0 0 {name=x93}
C {adc_sar_wafflecap_8_8.sym} 6120 -4270 0 0 {name=x94}
C {devices/lab_wire.sym} 1850 -4430 3 0 {name=l335 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -4430 3 0 {name=l336 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -4430 3 0 {name=l337 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -4430 3 0 {name=l338 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -4430 3 0 {name=l339 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -4430 3 0 {name=l340 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -4430 3 0 {name=l341 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -4430 3 0 {name=l342 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -4430 3 0 {name=l343 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -4430 3 0 {name=l344 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -4430 3 0 {name=l345 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -4430 3 0 {name=l346 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -4430 3 0 {name=l347 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -4430 3 0 {name=l348 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -4430 3 0 {name=l349 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -4670 2 1 {name=l351 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -4680 1 1 {name=l352 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -4680 3 0 {name=l353 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -4670 2 1 {name=l357 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -4680 1 1 {name=l358 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -4680 3 0 {name=l359 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -4670 2 1 {name=l360 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -4680 1 1 {name=l361 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -4680 3 0 {name=l362 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -4670 2 1 {name=l363 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -4680 1 1 {name=l364 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -4680 3 0 {name=l365 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -4670 2 1 {name=l366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -4680 1 1 {name=l367 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -4680 3 0 {name=l368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -4670 2 1 {name=l369 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -4680 1 1 {name=l370 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -4680 3 0 {name=l371 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -4670 2 1 {name=l372 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -4680 1 1 {name=l373 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -4680 3 0 {name=l374 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4670 2 1 {name=l375 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4680 1 1 {name=l376 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -4680 3 0 {name=l377 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -4670 2 1 {name=l378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -4680 1 1 {name=l379 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -4680 3 0 {name=l380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -4670 2 1 {name=l381 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -4680 1 1 {name=l382 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -4680 3 0 {name=l383 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4670 2 1 {name=l384 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4680 1 1 {name=l385 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -4680 3 0 {name=l386 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -4670 2 1 {name=l387 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -4680 1 1 {name=l388 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -4680 3 0 {name=l389 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -4670 2 1 {name=l390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -4680 1 1 {name=l391 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -4680 3 0 {name=l392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -4670 2 1 {name=l393 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -4680 1 1 {name=l394 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -4680 3 0 {name=l395 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -4670 2 1 {name=l396 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -4680 1 1 {name=l397 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -4680 3 0 {name=l398 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 1570 -4740 0 0 {name=x97}
C {adc_sar_wafflecap_8_8.sym} 1990 -4620 0 0 {name=x98}
C {adc_sar_wafflecap_8_8.sym} 2320 -4620 0 0 {name=x99}
C {adc_sar_wafflecap_8_8.sym} 2670 -4620 0 0 {name=x100}
C {adc_sar_wafflecap_8_8.sym} 3020 -4620 0 0 {name=x101}
C {adc_sar_wafflecap_8_8.sym} 3370 -4620 0 0 {name=x102}
C {adc_sar_wafflecap_8_8.sym} 3710 -4620 0 0 {name=x103}
C {adc_sar_wafflecap_8_8.sym} 4060 -4620 0 0 {name=x104}
C {adc_sar_wafflecap_8_8.sym} 4420 -4620 0 0 {name=x105}
C {adc_sar_wafflecap_8_8.sym} 4750 -4620 0 0 {name=x106}
C {adc_sar_wafflecap_8_8.sym} 5080 -4620 0 0 {name=x107}
C {adc_sar_wafflecap_8_8.sym} 5430 -4620 0 0 {name=x108}
C {adc_sar_wafflecap_8_8.sym} 5780 -4620 0 0 {name=x109}
C {adc_sar_wafflecap_8_8.sym} 6120 -4620 0 0 {name=x110}
C {devices/lab_wire.sym} 1850 -4780 3 0 {name=l399 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -4780 3 0 {name=l400 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -4780 3 0 {name=l401 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -4780 3 0 {name=l402 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -4780 3 0 {name=l403 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -4780 3 0 {name=l404 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -4780 3 0 {name=l405 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -4780 3 0 {name=l406 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -4780 3 0 {name=l407 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -4780 3 0 {name=l408 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -4780 3 0 {name=l409 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -4780 3 0 {name=l410 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -4780 3 0 {name=l411 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -4780 3 0 {name=l412 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -4780 3 0 {name=l413 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -5020 2 1 {name=l415 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -5030 1 1 {name=l416 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -5030 3 0 {name=l417 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -5020 2 1 {name=l421 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -5030 1 1 {name=l422 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -5030 3 0 {name=l423 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -5020 2 1 {name=l424 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -5030 1 1 {name=l425 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -5030 3 0 {name=l426 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -5020 2 1 {name=l427 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -5030 1 1 {name=l428 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -5030 3 0 {name=l429 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -5020 2 1 {name=l430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -5030 1 1 {name=l431 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -5030 3 0 {name=l432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -5020 2 1 {name=l433 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -5030 1 1 {name=l434 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -5030 3 0 {name=l435 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -5020 2 1 {name=l436 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -5030 1 1 {name=l437 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -5030 3 0 {name=l438 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5020 2 1 {name=l439 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5030 1 1 {name=l440 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -5030 3 0 {name=l441 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -5020 2 1 {name=l442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -5030 1 1 {name=l443 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -5030 3 0 {name=l444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -5020 2 1 {name=l445 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -5030 1 1 {name=l446 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -5030 3 0 {name=l447 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5020 2 1 {name=l448 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5030 1 1 {name=l449 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -5030 3 0 {name=l450 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -5020 2 1 {name=l451 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -5030 1 1 {name=l452 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -5030 3 0 {name=l453 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -5020 2 1 {name=l454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -5030 1 1 {name=l455 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -5030 3 0 {name=l456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -5020 2 1 {name=l457 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -5030 1 1 {name=l458 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -5030 3 0 {name=l459 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -5020 2 1 {name=l460 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -5030 1 1 {name=l461 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -5030 3 0 {name=l462 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1790 -4870 0 0 {name=l463 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -4930 0 0 {name=l464 sig_type=std_logic lab=row_n[5]}
C {devices/lab_wire.sym} 1790 -4910 0 0 {name=l465 sig_type=std_logic lab=rowon_n[5]}
C {devices/lab_wire.sym} 1790 -4890 0 0 {name=l466 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -5200 0 0 {name=l467 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -5260 0 0 {name=l468 sig_type=std_logic lab=row_n[6]}
C {devices/lab_wire.sym} 1790 -5240 0 0 {name=l469 sig_type=std_logic lab=rowon_n[6]}
C {devices/lab_wire.sym} 1790 -5220 0 0 {name=l470 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -4950 0 0 {name=l471 sig_type=std_logic lab=rowoff_n[5]}
C {devices/lab_wire.sym} 1790 -5280 0 0 {name=l472 sig_type=std_logic lab=rowoff_n[6]}
C {adc_sar_wafflecap_drv.sym} 1570 -5070 0 0 {name=x113}
C {adc_sar_wafflecap_8_8.sym} 1990 -4950 0 0 {name=x114}
C {adc_sar_wafflecap_8_8.sym} 2320 -4950 0 0 {name=x115}
C {adc_sar_wafflecap_8_8.sym} 2670 -4950 0 0 {name=x116}
C {adc_sar_wafflecap_8_8.sym} 3020 -4950 0 0 {name=x117}
C {adc_sar_wafflecap_8_8.sym} 3370 -4950 0 0 {name=x118}
C {adc_sar_wafflecap_8_8.sym} 3710 -4950 0 0 {name=x119}
C {adc_sar_wafflecap_8_8.sym} 4060 -4950 0 0 {name=x120}
C {adc_sar_wafflecap_8_8.sym} 4420 -4950 0 0 {name=x121}
C {adc_sar_wafflecap_8_8.sym} 4750 -4950 0 0 {name=x122}
C {adc_sar_wafflecap_8_8.sym} 5080 -4950 0 0 {name=x123}
C {adc_sar_wafflecap_8_8.sym} 5430 -4950 0 0 {name=x124}
C {adc_sar_wafflecap_8_8.sym} 5780 -4950 0 0 {name=x125}
C {adc_sar_wafflecap_8_8.sym} 6120 -4950 0 0 {name=x126}
C {devices/lab_wire.sym} 1850 -5110 3 0 {name=l473 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -5110 3 0 {name=l474 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -5110 3 0 {name=l475 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -5110 3 0 {name=l476 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -5110 3 0 {name=l477 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -5110 3 0 {name=l478 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -5110 3 0 {name=l479 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -5110 3 0 {name=l480 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -5110 3 0 {name=l481 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -5110 3 0 {name=l482 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -5110 3 0 {name=l483 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -5110 3 0 {name=l484 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -5110 3 0 {name=l485 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -5110 3 0 {name=l486 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -5110 3 0 {name=l487 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -5350 2 1 {name=l489 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -5360 1 1 {name=l490 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -5360 3 0 {name=l491 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -5350 2 1 {name=l495 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -5360 1 1 {name=l496 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -5360 3 0 {name=l497 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -5350 2 1 {name=l498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -5360 1 1 {name=l499 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -5360 3 0 {name=l500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -5350 2 1 {name=l501 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -5360 1 1 {name=l502 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -5360 3 0 {name=l503 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -5350 2 1 {name=l504 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -5360 1 1 {name=l505 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -5360 3 0 {name=l506 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -5350 2 1 {name=l507 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -5360 1 1 {name=l508 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -5360 3 0 {name=l509 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -5350 2 1 {name=l510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -5360 1 1 {name=l511 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -5360 3 0 {name=l512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5350 2 1 {name=l513 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5360 1 1 {name=l514 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -5360 3 0 {name=l515 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -5350 2 1 {name=l516 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -5360 1 1 {name=l517 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -5360 3 0 {name=l518 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -5350 2 1 {name=l519 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -5360 1 1 {name=l520 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -5360 3 0 {name=l521 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5350 2 1 {name=l522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5360 1 1 {name=l523 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -5360 3 0 {name=l524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -5350 2 1 {name=l525 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -5360 1 1 {name=l526 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -5360 3 0 {name=l527 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -5350 2 1 {name=l528 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -5360 1 1 {name=l529 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -5360 3 0 {name=l530 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -5350 2 1 {name=l531 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -5360 1 1 {name=l532 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -5360 3 0 {name=l533 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -5350 2 1 {name=l534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -5360 1 1 {name=l535 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -5360 3 0 {name=l536 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 1570 -5390 0 0 {name=x129}
C {adc_sar_wafflecap_8_8.sym} 1990 -5270 0 0 {name=x130}
C {adc_sar_wafflecap_8_8.sym} 2320 -5270 0 0 {name=x131}
C {adc_sar_wafflecap_8_8.sym} 2670 -5270 0 0 {name=x132}
C {adc_sar_wafflecap_8_8.sym} 3020 -5270 0 0 {name=x133}
C {adc_sar_wafflecap_8_8.sym} 3370 -5270 0 0 {name=x134}
C {adc_sar_wafflecap_8_8.sym} 3710 -5270 0 0 {name=x135}
C {adc_sar_wafflecap_8_8.sym} 4060 -5270 0 0 {name=x136}
C {adc_sar_wafflecap_8_8.sym} 4420 -5270 0 0 {name=x137}
C {adc_sar_wafflecap_8_8.sym} 4750 -5270 0 0 {name=x138}
C {adc_sar_wafflecap_8_8.sym} 5080 -5270 0 0 {name=x139}
C {adc_sar_wafflecap_8_8.sym} 5430 -5270 0 0 {name=x140}
C {adc_sar_wafflecap_8_8.sym} 5780 -5270 0 0 {name=x141}
C {adc_sar_wafflecap_8_8.sym} 6120 -5270 0 0 {name=x142}
C {devices/lab_wire.sym} 1850 -5430 3 0 {name=l537 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -5430 3 0 {name=l538 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -5430 3 0 {name=l539 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -5430 3 0 {name=l540 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -5430 3 0 {name=l541 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -5430 3 0 {name=l542 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -5430 3 0 {name=l543 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -5430 3 0 {name=l544 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -5430 3 0 {name=l545 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -5430 3 0 {name=l546 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -5430 3 0 {name=l547 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -5430 3 0 {name=l548 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -5430 3 0 {name=l549 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -5430 3 0 {name=l550 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -5430 3 0 {name=l551 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -5670 2 1 {name=l553 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -5680 1 1 {name=l554 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -5680 3 0 {name=l555 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -5670 2 1 {name=l559 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -5680 1 1 {name=l560 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -5680 3 0 {name=l561 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -5670 2 1 {name=l562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -5680 1 1 {name=l563 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -5680 3 0 {name=l564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -5670 2 1 {name=l565 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -5680 1 1 {name=l566 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -5680 3 0 {name=l567 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -5670 2 1 {name=l568 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -5680 1 1 {name=l569 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -5680 3 0 {name=l570 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -5670 2 1 {name=l571 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -5680 1 1 {name=l572 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -5680 3 0 {name=l573 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -5670 2 1 {name=l574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -5680 1 1 {name=l575 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -5680 3 0 {name=l576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5670 2 1 {name=l577 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5680 1 1 {name=l578 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -5680 3 0 {name=l579 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -5670 2 1 {name=l580 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -5680 1 1 {name=l581 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -5680 3 0 {name=l582 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -5670 2 1 {name=l583 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -5680 1 1 {name=l584 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -5680 3 0 {name=l585 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5670 2 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5680 1 1 {name=l587 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -5680 3 0 {name=l588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -5670 2 1 {name=l589 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -5680 1 1 {name=l590 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -5680 3 0 {name=l591 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -5670 2 1 {name=l592 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -5680 1 1 {name=l593 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -5680 3 0 {name=l594 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -5670 2 1 {name=l595 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -5680 1 1 {name=l596 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -5680 3 0 {name=l597 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -5670 2 1 {name=l598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -5680 1 1 {name=l599 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -5680 3 0 {name=l600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1790 -5520 0 0 {name=l601 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -5580 0 0 {name=l602 sig_type=std_logic lab=row_n[7]}
C {devices/lab_wire.sym} 1790 -5560 0 0 {name=l603 sig_type=std_logic lab=rowon_n[7]}
C {devices/lab_wire.sym} 1790 -5540 0 0 {name=l604 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -5850 0 0 {name=l605 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -5910 0 0 {name=l606 sig_type=std_logic lab=row_n[8]}
C {devices/lab_wire.sym} 1790 -5890 0 0 {name=l607 sig_type=std_logic lab=rowon_n[8]}
C {devices/lab_wire.sym} 1790 -5870 0 0 {name=l608 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -5600 0 0 {name=l609 sig_type=std_logic lab=rowoff_n[7]}
C {devices/lab_wire.sym} 1790 -5930 0 0 {name=l610 sig_type=std_logic lab=rowoff_n[8]}
C {adc_sar_wafflecap_drv.sym} 1570 -5720 0 0 {name=x145}
C {adc_sar_wafflecap_8_8.sym} 1990 -5600 0 0 {name=x146}
C {adc_sar_wafflecap_8_8.sym} 2320 -5600 0 0 {name=x147}
C {adc_sar_wafflecap_8_8.sym} 2670 -5600 0 0 {name=x148}
C {adc_sar_wafflecap_8_8.sym} 3020 -5600 0 0 {name=x149}
C {adc_sar_wafflecap_8_8.sym} 3370 -5600 0 0 {name=x150}
C {adc_sar_wafflecap_8_8.sym} 3710 -5600 0 0 {name=x151}
C {adc_sar_wafflecap_8_8.sym} 4060 -5600 0 0 {name=x152}
C {adc_sar_wafflecap_8_8.sym} 4420 -5600 0 0 {name=x153}
C {adc_sar_wafflecap_8_8.sym} 4750 -5600 0 0 {name=x154}
C {adc_sar_wafflecap_8_8.sym} 5080 -5600 0 0 {name=x155}
C {adc_sar_wafflecap_8_8.sym} 5430 -5600 0 0 {name=x156}
C {adc_sar_wafflecap_8_8.sym} 5780 -5600 0 0 {name=x157}
C {adc_sar_wafflecap_8_8.sym} 6120 -5600 0 0 {name=x158}
C {devices/lab_wire.sym} 1850 -5760 3 0 {name=l611 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -5760 3 0 {name=l612 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -5760 3 0 {name=l613 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -5760 3 0 {name=l614 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -5760 3 0 {name=l615 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -5760 3 0 {name=l616 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -5760 3 0 {name=l617 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -5760 3 0 {name=l618 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -5760 3 0 {name=l619 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -5760 3 0 {name=l620 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -5760 3 0 {name=l621 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -5760 3 0 {name=l622 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -5760 3 0 {name=l623 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -5760 3 0 {name=l624 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -5760 3 0 {name=l625 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -6000 2 1 {name=l627 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -6010 1 1 {name=l628 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -6010 3 0 {name=l629 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -6000 2 1 {name=l633 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -6010 1 1 {name=l634 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -6010 3 0 {name=l635 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -6000 2 1 {name=l636 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -6010 1 1 {name=l637 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -6010 3 0 {name=l638 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -6000 2 1 {name=l639 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -6010 1 1 {name=l640 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -6010 3 0 {name=l641 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -6000 2 1 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -6010 1 1 {name=l643 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -6010 3 0 {name=l644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -6000 2 1 {name=l645 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -6010 1 1 {name=l646 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -6010 3 0 {name=l647 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -6000 2 1 {name=l648 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -6010 1 1 {name=l649 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -6010 3 0 {name=l650 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6000 2 1 {name=l651 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6010 1 1 {name=l652 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -6010 3 0 {name=l653 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -6000 2 1 {name=l654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -6010 1 1 {name=l655 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -6010 3 0 {name=l656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -6000 2 1 {name=l657 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -6010 1 1 {name=l658 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -6010 3 0 {name=l659 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6000 2 1 {name=l660 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6010 1 1 {name=l661 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -6010 3 0 {name=l662 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -6000 2 1 {name=l663 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -6010 1 1 {name=l664 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -6010 3 0 {name=l665 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -6000 2 1 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -6010 1 1 {name=l667 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -6010 3 0 {name=l668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -6000 2 1 {name=l669 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -6010 1 1 {name=l670 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -6010 3 0 {name=l671 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -6000 2 1 {name=l672 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -6010 1 1 {name=l673 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -6010 3 0 {name=l674 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 1570 -6030 0 0 {name=x161}
C {adc_sar_wafflecap_8_8.sym} 1990 -5910 0 0 {name=x162}
C {adc_sar_wafflecap_8_8.sym} 2320 -5910 0 0 {name=x163}
C {adc_sar_wafflecap_8_8.sym} 2670 -5910 0 0 {name=x164}
C {adc_sar_wafflecap_8_8.sym} 3020 -5910 0 0 {name=x165}
C {adc_sar_wafflecap_8_8.sym} 3370 -5910 0 0 {name=x166}
C {adc_sar_wafflecap_8_8.sym} 3710 -5910 0 0 {name=x167}
C {adc_sar_wafflecap_8_8.sym} 4060 -5910 0 0 {name=x168}
C {adc_sar_wafflecap_8_8.sym} 4420 -5910 0 0 {name=x169}
C {adc_sar_wafflecap_8_8.sym} 4750 -5910 0 0 {name=x170}
C {adc_sar_wafflecap_8_8.sym} 5080 -5910 0 0 {name=x171}
C {adc_sar_wafflecap_8_8.sym} 5430 -5910 0 0 {name=x172}
C {adc_sar_wafflecap_8_8.sym} 5780 -5910 0 0 {name=x173}
C {adc_sar_wafflecap_8_8.sym} 6120 -5910 0 0 {name=x174}
C {devices/lab_wire.sym} 1850 -6070 3 0 {name=l675 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -6070 3 0 {name=l676 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -6070 3 0 {name=l677 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -6070 3 0 {name=l678 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -6070 3 0 {name=l679 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -6070 3 0 {name=l680 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -6070 3 0 {name=l681 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -6070 3 0 {name=l682 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -6070 3 0 {name=l683 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -6070 3 0 {name=l684 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -6070 3 0 {name=l685 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -6070 3 0 {name=l686 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -6070 3 0 {name=l687 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -6070 3 0 {name=l688 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -6070 3 0 {name=l689 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -6310 2 1 {name=l691 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -6320 1 1 {name=l692 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -6320 3 0 {name=l693 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -6310 2 1 {name=l697 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -6320 1 1 {name=l698 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -6320 3 0 {name=l699 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -6310 2 1 {name=l700 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -6320 1 1 {name=l701 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -6320 3 0 {name=l702 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -6310 2 1 {name=l703 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -6320 1 1 {name=l704 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -6320 3 0 {name=l705 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -6310 2 1 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -6320 1 1 {name=l707 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -6320 3 0 {name=l708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -6310 2 1 {name=l709 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -6320 1 1 {name=l710 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -6320 3 0 {name=l711 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -6310 2 1 {name=l712 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -6320 1 1 {name=l713 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -6320 3 0 {name=l714 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6310 2 1 {name=l715 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6320 1 1 {name=l716 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -6320 3 0 {name=l717 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -6310 2 1 {name=l718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -6320 1 1 {name=l719 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -6320 3 0 {name=l720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -6310 2 1 {name=l721 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -6320 1 1 {name=l722 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -6320 3 0 {name=l723 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6310 2 1 {name=l724 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6320 1 1 {name=l725 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -6320 3 0 {name=l726 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -6310 2 1 {name=l727 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -6320 1 1 {name=l728 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -6320 3 0 {name=l729 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -6310 2 1 {name=l730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -6320 1 1 {name=l731 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -6320 3 0 {name=l732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -6310 2 1 {name=l733 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -6320 1 1 {name=l734 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -6320 3 0 {name=l735 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -6310 2 1 {name=l736 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -6320 1 1 {name=l737 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -6320 3 0 {name=l738 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1790 -6160 0 0 {name=l739 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -6220 0 0 {name=l740 sig_type=std_logic lab=row_n[9]}
C {devices/lab_wire.sym} 1790 -6200 0 0 {name=l741 sig_type=std_logic lab=rowon_n[9]}
C {devices/lab_wire.sym} 1790 -6180 0 0 {name=l742 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -6490 0 0 {name=l743 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 1790 -6550 0 0 {name=l744 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1790 -6530 0 0 {name=l745 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1790 -6510 0 0 {name=l746 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 1790 -6240 0 0 {name=l747 sig_type=std_logic lab=rowoff_n[9]}
C {devices/lab_wire.sym} 1790 -6570 0 0 {name=l748 sig_type=std_logic lab=VSS}
C {adc_sar_wafflecap_drv.sym} 1570 -6360 0 0 {name=x177}
C {devices/lab_wire.sym} 1850 -6400 3 0 {name=l749 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2170 -6400 3 0 {name=l750 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -6400 3 0 {name=l751 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2850 -6400 3 0 {name=l752 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -6400 3 0 {name=l753 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -6400 3 0 {name=l754 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3890 -6400 3 0 {name=l755 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -6400 3 0 {name=l756 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4600 -6400 3 0 {name=l757 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4930 -6400 3 0 {name=l758 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -6400 3 0 {name=l759 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5610 -6400 3 0 {name=l760 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5960 -6400 3 0 {name=l761 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6300 -6400 3 0 {name=l762 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -6400 3 0 {name=l763 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6640 -6640 2 1 {name=l765 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6660 -6650 1 1 {name=l766 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6700 -6650 3 0 {name=l767 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5960 -6640 2 1 {name=l771 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5980 -6650 1 1 {name=l772 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6020 -6650 3 0 {name=l773 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6300 -6640 2 1 {name=l774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6320 -6650 1 1 {name=l775 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6360 -6650 3 0 {name=l776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5610 -6640 2 1 {name=l777 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -6650 1 1 {name=l778 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5670 -6650 3 0 {name=l779 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5260 -6640 2 1 {name=l780 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5280 -6650 1 1 {name=l781 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5320 -6650 3 0 {name=l782 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4930 -6640 2 1 {name=l783 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4950 -6650 1 1 {name=l784 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4990 -6650 3 0 {name=l785 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4600 -6640 2 1 {name=l786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4620 -6650 1 1 {name=l787 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4660 -6650 3 0 {name=l788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6640 2 1 {name=l789 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6650 1 1 {name=l790 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4300 -6650 3 0 {name=l791 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3890 -6640 2 1 {name=l792 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3910 -6650 1 1 {name=l793 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3950 -6650 3 0 {name=l794 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -6640 2 1 {name=l795 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -6650 1 1 {name=l796 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -6650 3 0 {name=l797 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6640 2 1 {name=l798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6650 1 1 {name=l799 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3260 -6650 3 0 {name=l800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2850 -6640 2 1 {name=l801 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2870 -6650 1 1 {name=l802 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2910 -6650 3 0 {name=l803 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -6640 2 1 {name=l804 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -6650 1 1 {name=l805 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -6650 3 0 {name=l806 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2170 -6640 2 1 {name=l807 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2190 -6650 1 1 {name=l808 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2230 -6650 3 0 {name=l809 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1850 -6640 2 1 {name=l810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -6650 1 1 {name=l811 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1910 -6650 3 0 {name=l812 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_dummy.sym} 6060 -6320 0 0 {name=x180}
C {adc_sar_wafflecap_dummy.sym} 5720 -6320 0 0 {name=x181}
C {adc_sar_wafflecap_dummy.sym} 5370 -6320 0 0 {name=x182}
C {adc_sar_wafflecap_dummy.sym} 5020 -6320 0 0 {name=x183}
C {adc_sar_wafflecap_dummy.sym} 4690 -6320 0 0 {name=x184}
C {adc_sar_wafflecap_dummy.sym} 4360 -6320 0 0 {name=x185}
C {adc_sar_wafflecap_dummy.sym} 4000 -6320 0 0 {name=x186}
C {adc_sar_wafflecap_dummy.sym} 3650 -6320 0 0 {name=x187}
C {adc_sar_wafflecap_dummy.sym} 3310 -6320 0 0 {name=x188}
C {adc_sar_wafflecap_dummy.sym} 2960 -6320 0 0 {name=x189}
C {adc_sar_wafflecap_dummy.sym} 2610 -6320 0 0 {name=x190}
C {adc_sar_wafflecap_dummy.sym} 2260 -6320 0 0 {name=x191}
C {adc_sar_wafflecap_dummy.sym} 1930 -6320 0 0 {name=x192}
C {adc_sar_wafflecap_gate.sym} 5960 -2800 0 0 {name=x14}
C {adc_sar_wafflecap_dummy.sym} 6400 -2750 0 0 {name=x15}
C {adc_sar_wafflecap_dummy.sym} 6400 -3370 0 0 {name=x16}
C {adc_sar_wafflecap_dummy.sym} 6400 -3700 0 0 {name=x32}
C {adc_sar_wafflecap_dummy.sym} 6400 -4020 0 0 {name=x47}
C {adc_sar_wafflecap_dummy.sym} 6400 -4350 0 0 {name=x48}
C {adc_sar_wafflecap_dummy.sym} 6400 -4700 0 0 {name=x63}
C {adc_sar_wafflecap_dummy.sym} 6400 -5030 0 0 {name=x64}
C {adc_sar_wafflecap_dummy.sym} 6400 -5350 0 0 {name=x79}
C {adc_sar_wafflecap_dummy.sym} 6400 -5680 0 0 {name=x80}
C {adc_sar_wafflecap_dummy.sym} 6400 -5990 0 0 {name=x95}
C {adc_sar_wafflecap_dummy.sym} 6400 -6320 0 0 {name=x96}
C {devices/ipin.sym} 3390 -1620 0 0 {name=p20 lab=sample}
C {devices/ipin.sym} 3390 -1480 0 0 {name=p21 lab=sample_n}
C {devices/code_shown.sym} 3510 -2470 0 0 {name=NGSPICE1 only_toplevel=true
value="
.tran 0.1n 20u 0 0.05n
.save all
"}
C {devices/code_shown.sym} 3520 -2320 0 0 {name=MODELS1 only_toplevel=true
format="tcleval( @value )"
value="
.include /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/smbb000149.ngspice typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice mimcap_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice res_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice moscap_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice diode_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/sm141064.ngspice typical
"}
C {adc_sar_vcm_generator.sym} 3810 -1680 0 0 {name=x111}
C {vdd.sym} 3980 -1970 0 0 {name=l32 lab=VDD}
C {gnd.sym} 3980 -1810 0 0 {name=l33 lab=GND}
C {devices/capa.sym} 4190 -1860 0 0 {name=C1
m=1
value=6p
footprint=1206
device="ceramic capacitor"}
C {devices/res.sym} 4290 -1860 0 0 {name=R1
value=100Meg
footprint=1206
device=resistor
m=1}
C {gnd.sym} 4290 -1800 0 0 {name=l49 lab=GND}
C {gnd.sym} 4190 -1800 0 0 {name=l114 lab=GND}
C {vsource.sym} 3870 -1860 0 0 {name=V1 value="0 pulse(0 3.3 15u 10p 10p 15u 30u)" savecurrent=false}
C {gnd.sym} 3870 -1810 0 0 {name=l115 lab=GND}
C {devices/vsource.sym} 3740 -1970 0 0 {name=V2 value=3.3}
C {devices/gnd.sym} 3740 -1920 0 0 {name=l116 lab=GND}
C {devices/vdd.sym} 3740 -2020 0 0 {name=l117 lab=VDD}
C {adc_sar_sample_and_hole.sym} 3980 -1540 0 0 {name=x112}
C {ipin.sym} 3830 -1580 0 0 {name=p1 lab=Vinp}
C {vdd.sym} 3730 -1550 0 0 {name=l118 lab=VDD}
C {gnd.sym} 3720 -1430 0 0 {name=l119 lab=GND}
C {vsource.sym} 3380 -1860 0 0 {name=V4 value="SIN(0.9 0.9 10Meg) DC 0" savecurrent=false}
C {ipin.sym} 3380 -1890 0 0 {name=p8 lab=Vinp}
C {vsource.sym} 3380 -1710 0 0 {name=V5 value=0 savecurrent=false}
C {gnd.sym} 3380 -1680 0 0 {name=l126 lab=GND}
C {vsource.sym} 3390 -1590 0 0 {name=V3 value="PULSE(0 3.3 0 0.5n 0.5n 40n 100n)
" savecurrent=false}
C {gnd.sym} 3390 -1560 0 0 {name=l127 lab=GND}
C {vsource.sym} 3390 -1450 0 0 {name=V6 value="PULSE(3.3 0 0 0.5n 0.5n 40n 100n)
" savecurrent=false}
C {gnd.sym} 3390 -1420 0 0 {name=l128 lab=GND}
C {devices/iopin.sym} 4320 -1890 2 1 {name=p4 lab=vcm}
C {devices/iopin.sym} 4250 -1540 0 0 {name=p5 lab=analog_in}
C {devices/ipin.sym} 3710 -1540 0 0 {name=p2 lab=sample}
C {devices/ipin.sym} 3710 -1520 0 0 {name=p3 lab=sample_n}
C {devices/iopin.sym} 3890 -1350 2 0 {name=p6 lab=VSS}
C {gnd.sym} 3890 -1270 0 0 {name=l132 lab=GND}
C {devices/iopin.sym} 4110 -1320 2 0 {name=p7 lab=ctop}
C {devices/ipin.sym} 3100 -1880 0 0 {name=p9 lab=sw}
C {devices/ipin.sym} 3100 -1570 0 0 {name=p10 lab=sw_n}
C {devices/vsource.sym} 3100 -1800 0 0 {name=V7 value=3.3}
C {gnd.sym} 3100 -1750 0 0 {name=l133 lab=GND}
C {devices/vsource.sym} 3100 -1510 0 0 {name=V8 value=0}
C {gnd.sym} 3100 -1460 0 0 {name=l134 lab=GND}
C {devices/ipin.sym} 2380 -2000 0 0 {name=p12 lab=row_n[0]}
C {devices/vsource.sym} 2380 -1930 0 0 {name=V9 value=3.3}
C {gnd.sym} 2380 -1870 0 0 {name=l280 lab=GND}
C {devices/ipin.sym} 2380 -1790 0 0 {name=p13 lab=row_n[1]}
C {devices/vsource.sym} 2380 -1720 0 0 {name=V10 value=3.3}
C {gnd.sym} 2380 -1660 0 0 {name=l281 lab=GND}
C {devices/ipin.sym} 2380 -1580 0 0 {name=p14 lab=row_n[2]}
C {devices/vsource.sym} 2380 -1510 0 0 {name=V11 value=0}
C {gnd.sym} 2380 -1450 0 0 {name=l282 lab=GND}
C {devices/ipin.sym} 2380 -1360 0 0 {name=p15 lab=row_n[3]}
C {devices/vsource.sym} 2380 -1290 0 0 {name=V12 value=0}
C {gnd.sym} 2380 -1230 0 0 {name=l350 lab=GND}
C {devices/ipin.sym} 2380 -1150 0 0 {name=p16 lab=row_n[4]}
C {devices/vsource.sym} 2380 -1080 0 0 {name=V13 value=0}
C {gnd.sym} 2380 -1020 0 0 {name=l354 lab=GND}
C {devices/ipin.sym} 2580 -2000 0 0 {name=p33 lab=row_n[5]}
C {devices/vsource.sym} 2580 -1930 0 0 {name=V14 value=0}
C {gnd.sym} 2580 -1870 0 0 {name=l355 lab=GND}
C {devices/ipin.sym} 2580 -1800 0 0 {name=p34 lab=row_n[6]}
C {devices/vsource.sym} 2580 -1730 0 0 {name=V15 value=0}
C {gnd.sym} 2580 -1670 0 0 {name=l356 lab=GND}
C {devices/ipin.sym} 2580 -1590 0 0 {name=p35 lab=row_n[7]}
C {devices/vsource.sym} 2580 -1520 0 0 {name=V16 value=0}
C {gnd.sym} 2580 -1460 0 0 {name=l414 lab=GND}
C {devices/ipin.sym} 2580 -1360 0 0 {name=p36 lab=row_n[8]}
C {devices/vsource.sym} 2580 -1290 0 0 {name=V17 value=0}
C {gnd.sym} 2580 -1230 0 0 {name=l418 lab=GND}
C {devices/ipin.sym} 2580 -1150 0 0 {name=p37 lab=row_n[9]}
C {devices/vsource.sym} 2580 -1080 0 0 {name=V18 value=0}
C {gnd.sym} 2580 -1020 0 0 {name=l419 lab=GND}
C {devices/ipin.sym} 1870 -2000 0 0 {name=p38 lab=rowon_n[0]}
C {devices/vsource.sym} 1870 -1930 0 0 {name=V19 value=3.3}
C {gnd.sym} 1870 -1870 0 0 {name=l420 lab=GND}
C {devices/ipin.sym} 1870 -1790 0 0 {name=p39 lab=rowon_n[1]}
C {devices/vsource.sym} 1870 -1720 0 0 {name=V20 value=3.3}
C {gnd.sym} 1870 -1660 0 0 {name=l488 lab=GND}
C {devices/ipin.sym} 1870 -1580 0 0 {name=p40 lab=rowon_n[2]}
C {devices/vsource.sym} 1870 -1510 0 0 {name=V21 value=0}
C {gnd.sym} 1870 -1450 0 0 {name=l492 lab=GND}
C {devices/ipin.sym} 1870 -1360 0 0 {name=p41 lab=rowon_n[3]}
C {devices/vsource.sym} 1870 -1290 0 0 {name=V22 value=0}
C {gnd.sym} 1870 -1230 0 0 {name=l493 lab=GND}
C {devices/ipin.sym} 1870 -1150 0 0 {name=p42 lab=rowon_n[4]}
C {devices/vsource.sym} 1870 -1080 0 0 {name=V23 value=0}
C {gnd.sym} 1870 -1020 0 0 {name=l494 lab=GND}
C {devices/ipin.sym} 2070 -2000 0 0 {name=p43 lab=rowon_n[5]}
C {devices/vsource.sym} 2070 -1930 0 0 {name=V24 value=0}
C {gnd.sym} 2070 -1870 0 0 {name=l552 lab=GND}
C {devices/ipin.sym} 2070 -1800 0 0 {name=p44 lab=rowon_n[6]}
C {devices/vsource.sym} 2070 -1730 0 0 {name=V25 value=0}
C {gnd.sym} 2070 -1670 0 0 {name=l556 lab=GND}
C {devices/ipin.sym} 2070 -1590 0 0 {name=p45 lab=rowon_n[7]}
C {devices/vsource.sym} 2070 -1520 0 0 {name=V26 value=0}
C {gnd.sym} 2070 -1460 0 0 {name=l557 lab=GND}
C {devices/ipin.sym} 2070 -1360 0 0 {name=p46 lab=rowon_n[8]}
C {devices/vsource.sym} 2070 -1290 0 0 {name=V27 value=0}
C {gnd.sym} 2070 -1230 0 0 {name=l558 lab=GND}
C {devices/ipin.sym} 2070 -1150 0 0 {name=p47 lab=rowon_n[9]}
C {devices/vsource.sym} 2070 -1080 0 0 {name=V28 value=0}
C {gnd.sym} 2070 -1020 0 0 {name=l626 lab=GND}
C {devices/ipin.sym} 1340 -1990 0 0 {name=p48 lab=rowoff_n[0]}
C {devices/vsource.sym} 1340 -1920 0 0 {name=V29 value=0}
C {gnd.sym} 1340 -1860 0 0 {name=l630 lab=GND}
C {devices/ipin.sym} 1340 -1780 0 0 {name=p49 lab=rowoff_n[1]}
C {devices/vsource.sym} 1340 -1710 0 0 {name=V30 value=0}
C {gnd.sym} 1340 -1650 0 0 {name=l631 lab=GND}
C {devices/ipin.sym} 1340 -1570 0 0 {name=p50 lab=rowoff_n[2]}
C {devices/vsource.sym} 1340 -1500 0 0 {name=V31 value=0}
C {gnd.sym} 1340 -1440 0 0 {name=l632 lab=GND}
C {devices/ipin.sym} 1340 -1350 0 0 {name=p51 lab=rowoff_n[3]}
C {devices/vsource.sym} 1340 -1280 0 0 {name=V32 value=0}
C {gnd.sym} 1340 -1220 0 0 {name=l690 lab=GND}
C {devices/ipin.sym} 1340 -1140 0 0 {name=p52 lab=rowoff_n[4]}
C {devices/vsource.sym} 1340 -1070 0 0 {name=V33 value=0}
C {gnd.sym} 1340 -1010 0 0 {name=l694 lab=GND}
C {devices/ipin.sym} 1540 -1990 0 0 {name=p53 lab=rowoff_n[5]}
C {devices/vsource.sym} 1540 -1920 0 0 {name=V34 value=0}
C {gnd.sym} 1540 -1860 0 0 {name=l695 lab=GND}
C {devices/ipin.sym} 1540 -1790 0 0 {name=p54 lab=rowoff_n[6]}
C {devices/vsource.sym} 1540 -1720 0 0 {name=V35 value=0}
C {gnd.sym} 1540 -1660 0 0 {name=l696 lab=GND}
C {devices/ipin.sym} 1540 -1580 0 0 {name=p55 lab=rowoff_n[7]}
C {devices/vsource.sym} 1540 -1510 0 0 {name=V36 value=0}
C {gnd.sym} 1540 -1450 0 0 {name=l764 lab=GND}
C {devices/ipin.sym} 1540 -1350 0 0 {name=p56 lab=rowoff_n[8]}
C {devices/vsource.sym} 1540 -1280 0 0 {name=V37 value=0}
C {gnd.sym} 1540 -1220 0 0 {name=l768 lab=GND}
C {devices/ipin.sym} 1540 -1140 0 0 {name=p57 lab=rowoff_n[9]}
C {devices/vsource.sym} 1540 -1070 0 0 {name=V38 value=0}
C {gnd.sym} 1540 -1010 0 0 {name=l769 lab=GND}
C {devices/ipin.sym} 1340 -850 0 0 {name=p58 lab=col_n[0]}
C {devices/vsource.sym} 1340 -790 0 0 {name=V39 value=0}
C {gnd.sym} 1340 -740 0 0 {name=l770 lab=GND}
C {devices/ipin.sym} 1340 -690 0 0 {name=p59 lab=col_n[1]}
C {devices/vsource.sym} 1340 -630 0 0 {name=V40 value=0}
C {gnd.sym} 1340 -580 0 0 {name=l813 lab=GND}
C {devices/ipin.sym} 1340 -520 0 0 {name=p60 lab=col_n[2]}
C {devices/vsource.sym} 1340 -460 0 0 {name=V41 value=0}
C {gnd.sym} 1340 -410 0 0 {name=l814 lab=GND}
C {devices/ipin.sym} 1340 -360 0 0 {name=p61 lab=col_n[3]}
C {devices/vsource.sym} 1340 -300 0 0 {name=V42 value=0}
C {gnd.sym} 1340 -250 0 0 {name=l815 lab=GND}
C {devices/ipin.sym} 1540 -860 0 0 {name=p62 lab=col_n[4]}
C {devices/vsource.sym} 1540 -800 0 0 {name=V43 value=0}
C {gnd.sym} 1540 -750 0 0 {name=l816 lab=GND}
C {devices/ipin.sym} 1540 -700 0 0 {name=p63 lab=col_n[5]}
C {devices/vsource.sym} 1540 -640 0 0 {name=V44 value=0}
C {gnd.sym} 1540 -590 0 0 {name=l817 lab=GND}
C {devices/ipin.sym} 1540 -530 0 0 {name=p64 lab=col_n[6]}
C {devices/vsource.sym} 1540 -470 0 0 {name=V45 value=0}
C {gnd.sym} 1540 -420 0 0 {name=l818 lab=GND}
C {devices/ipin.sym} 1540 -370 0 0 {name=p65 lab=col_n[7]}
C {devices/vsource.sym} 1540 -310 0 0 {name=V46 value=0}
C {gnd.sym} 1540 -260 0 0 {name=l819 lab=GND}
C {devices/ipin.sym} 1750 -860 0 0 {name=p66 lab=col_n[8]}
C {devices/vsource.sym} 1750 -800 0 0 {name=V47 value=0}
C {gnd.sym} 1750 -750 0 0 {name=l820 lab=GND}
C {devices/ipin.sym} 1750 -700 0 0 {name=p67 lab=col_n[9]}
C {devices/vsource.sym} 1750 -640 0 0 {name=V48 value=0}
C {gnd.sym} 1750 -590 0 0 {name=l821 lab=GND}
C {devices/ipin.sym} 1750 -530 0 0 {name=p68 lab=col_n[10]}
C {devices/vsource.sym} 1750 -470 0 0 {name=V49 value=0}
C {gnd.sym} 1750 -420 0 0 {name=l822 lab=GND}
C {devices/ipin.sym} 1750 -370 0 0 {name=p69 lab=col_n[11]}
C {devices/vsource.sym} 1750 -310 0 0 {name=V50 value=0}
C {gnd.sym} 1750 -260 0 0 {name=l823 lab=GND}
C {devices/ipin.sym} 1530 -180 0 0 {name=p71 lab=col_n[12]}
C {devices/vsource.sym} 1530 -120 0 0 {name=V52 value=0}
C {gnd.sym} 1530 -70 0 0 {name=l825 lab=GND}
C {devices/vsource.sym} 1920 -810 0 0 {name=V51 value=3.3}
C {gnd.sym} 1920 -760 0 0 {name=l824 lab=GND}
C {devices/ipin.sym} 1920 -860 0 0 {name=p70 lab=col[0]}
C {devices/vsource.sym} 1920 -660 0 0 {name=V53 value=3.3}
C {gnd.sym} 1920 -610 0 0 {name=l826 lab=GND}
C {devices/ipin.sym} 1920 -710 0 0 {name=p72 lab=col[1]}
C {devices/vsource.sym} 1920 -510 0 0 {name=V54 value=3.3}
C {gnd.sym} 1920 -460 0 0 {name=l827 lab=GND}
C {devices/ipin.sym} 1920 -560 0 0 {name=p73 lab=col[2]}
C {devices/vsource.sym} 1920 -350 0 0 {name=V55 value=3.3}
C {gnd.sym} 1920 -300 0 0 {name=l828 lab=GND}
C {devices/ipin.sym} 1920 -400 0 0 {name=p74 lab=col[3]}
C {devices/vsource.sym} 2040 -820 0 0 {name=V56 value=3.3}
C {gnd.sym} 2040 -770 0 0 {name=l829 lab=GND}
C {devices/ipin.sym} 2040 -870 0 0 {name=p75 lab=col[4]}
C {devices/vsource.sym} 2040 -660 0 0 {name=V57 value=3.3}
C {gnd.sym} 2040 -610 0 0 {name=l830 lab=GND}
C {devices/ipin.sym} 2040 -710 0 0 {name=p76 lab=col[5]}
C {devices/vsource.sym} 2040 -500 0 0 {name=V58 value=3.3}
C {gnd.sym} 2040 -450 0 0 {name=l831 lab=GND}
C {devices/ipin.sym} 2040 -550 0 0 {name=p77 lab=col[6]}
C {devices/vsource.sym} 2030 -350 0 0 {name=V59 value=3.3}
C {gnd.sym} 2030 -300 0 0 {name=l832 lab=GND}
C {devices/ipin.sym} 2030 -400 0 0 {name=p78 lab=col[7]}
C {devices/vsource.sym} 2170 -840 0 0 {name=V60 value=3.3}
C {gnd.sym} 2170 -790 0 0 {name=l833 lab=GND}
C {devices/ipin.sym} 2170 -890 0 0 {name=p79 lab=col[8]}
C {devices/vsource.sym} 2160 -670 0 0 {name=V61 value=3.3}
C {gnd.sym} 2160 -620 0 0 {name=l834 lab=GND}
C {devices/ipin.sym} 2160 -720 0 0 {name=p80 lab=col[9]}
C {devices/vsource.sym} 2160 -500 0 0 {name=V62 value=3.3}
C {gnd.sym} 2160 -450 0 0 {name=l835 lab=GND}
C {devices/ipin.sym} 2160 -550 0 0 {name=p81 lab=col[10]}
C {devices/vsource.sym} 2160 -340 0 0 {name=V63 value=3.3}
C {gnd.sym} 2160 -290 0 0 {name=l836 lab=GND}
C {devices/ipin.sym} 2160 -390 0 0 {name=p82 lab=col[11]}
C {devices/vsource.sym} 2280 -680 0 0 {name=V64 value=3.3}
C {gnd.sym} 2280 -630 0 0 {name=l837 lab=GND}
C {devices/ipin.sym} 2280 -730 0 0 {name=p83 lab=col[12]}
C {devices/vsource.sym} 3030 -1180 0 0 {name=V65 value=3.3}
C {devices/vsource.sym} 3180 -1180 0 0 {name=V66 value=3.3}
C {devices/vsource.sym} 3320 -1180 0 0 {name=V67 value=0}
C {gnd.sym} 3030 -1120 0 0 {name=l838 lab=GND}
C {gnd.sym} 3180 -1120 0 0 {name=l839 lab=GND}
C {gnd.sym} 3320 -1120 0 0 {name=l840 lab=GND}
C {devices/ipin.sym} 3030 -1230 0 0 {name=p84 lab=en_bit_n[0]}
C {devices/ipin.sym} 3180 -1230 0 0 {name=p85 lab=en_bit_n[1]}
C {devices/ipin.sym} 3320 -1230 0 0 {name=p86 lab=en_bit_n[2]}
C {devices/vsource.sym} 3490 -1180 0 0 {name=V68 value=3.3}
C {gnd.sym} 3490 -1120 0 0 {name=l841 lab=GND}
C {devices/ipin.sym} 3490 -1240 0 0 {name=p87 lab=en_C0_n}
C {devices/vsource.sym} 3890 -1320 0 0 {name=V69 value=0}
